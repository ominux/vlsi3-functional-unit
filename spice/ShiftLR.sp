$ Spice netlist generated by v2lvs
$ v2007.1_31.29    Wed Apr  4 12:35:05 PDT 2007
.INCLUDE "design_model.inc"

.SUBCKT ShiftLR Z[31] Z[30] Z[29] Z[28] Z[27] Z[26] Z[25] Z[24] Z[23] Z[22]
+ Z[21] Z[20] Z[19] Z[18] Z[17] Z[16] Z[15] Z[14] Z[13] Z[12] Z[11] Z[10] Z[9]
+ Z[8] Z[7] Z[6] Z[5] Z[4] Z[3] Z[2] Z[1] Z[0] X[31] X[30] X[29] X[28] X[27]
+ X[26] X[25] X[24] X[23] X[22] X[21] X[20] X[19] X[18] X[17] X[16] X[15] X[14]
+ X[13] X[12] X[11] X[10] X[9] X[8] X[7] X[6] X[5] X[4] X[3] X[2] X[1] X[0]
+ S[4] S[3] S[2] S[1] S[0] LEFT LOG
XU289 n131 n38 n261 n150 n281 n36 n123 SEN_OAI222_1
XU290 n123 S[2] n256 SEN_EO2_DG_4
XU291 n256 n342 n294 SEN_NR2B_V1DG_2
XU292 n281 n104 SEN_BUF_S_1
XU293 n78 n137 SEN_INV_2
XU294 n275 n99 SEN_BUF_S_1
XU295 n333 n349 n167 SEN_ND2_0P5
XU296 n190 n268 n269 n152 SEN_NR3_G_1
XU297 n280 n104 SEN_BUF_S_1
XU298 n23 n207 SEN_INV_S_1
XU299 n151 n66 n158 n39 n172 SEN_OAI211_1
XU300 n172 n160 n344 n173 n37 SEN_AOI22_1
XU301 n321 n115 n81 n50 n83 n200 n84 SEN_AO222_1
XU302 n213 n115 n79 n170 n81 n226 SEN_AOI221_1
XU303 n209 n24 n79 n164 n81 n223 SEN_AOI221_1
XU304 n201 n17 n79 n178 n81 n215 SEN_AOI221_1
XU305 n167 n285 n286 n259 SEN_OR3_1
XU306 n34 n148 SEN_INV_S_1
XU307 n81 n279 SEN_INV_S_1
XU308 n279 n104 SEN_BUF_S_1
XU309 n84 n123 SEN_INV_2
XU310 n83 n108 SEN_INV_S_1
XU311 n184 n355 n179 n350 n183 n347 n22 SEN_AOI222_1
XU312 Z[29] n266 n267 n149 SEN_ND3_1
XU313 n149 n318 n319 n320 SEN_AN3_1
XU314 n94 n116 n317 n188 n280 n237 SEN_OAI221_1
XU315 n257 n79 n258 SEN_AN2_S_1
XU316 n352 n257 SEN_INV_S_0P5
XU317 n351 n257 SEN_INV_S_0P5
XU318 n258 n130 n212 n86 SEN_AN3_0P5
XU319 n195 n113 n317 n190 n280 n211 SEN_OAI221_1
XU320 n355 n238 SEN_INV_2
XU321 n39 n152 SEN_INV_1
XU322 n349 n338 SEN_INV_S_1
XU323 n259 n79 n28 n81 n133 SEN_AO22_1
XU324 n32 n216 SEN_INV_1
XU325 n284 n195 SEN_INV_S_1
XU326 n137 n212 n342 SEN_ND2_G_1
XU327 n132 n133 n83 n134 n81 n135 n84 SEN_AOI222_1
XU328 n129 n130 n131 n130 n132 SEN_OA2BB2_0P5
XU329 n103 n345 X[21] n337 X[5] n32 SEN_AOI221_1
XU330 n337 n331 SEN_INV_2
XU331 n235 n83 n24 n106 n103 SEN_OA2BB2_DG_1
XU332 n340 n197 n130 SEN_AN2_DG_1
XU333 n261 n173 n123 SEN_ND2_G_1
XU334 n260 n80 SEN_INV_S_1
XU335 n215 n261 n193 n106 n175 SEN_OAI22_S_0P5
XU336 n185 n106 n166 n83 n164 SEN_AO2BB2_0P5
XU337 n106 n84 n82 SEN_ND2_G_1
XU338 n108 n173 n123 SEN_ND2_G_0P65
XU339 n135 n64 n158 n39 n159 SEN_OAI211_0P5
XU340 n158 n78 n82 SEN_ND2_T_0P5
XU341 n175 n346 X[27] n337 X[11] n32 SEN_AOI221_1
XU342 n262 n345 X[22] SEN_ND2_G_1
XU343 n263 n336 X[6] SEN_ND2_G_1
XU344 n203 n262 n263 n297 SEN_AN3_1
XU345 n336 n331 SEN_INV_2
XU346 n264 n346 X[19] SEN_AN2_S_1
XU347 n265 n337 X[3] SEN_AN2_S_0P5
XU348 n120 n264 n265 n32 SEN_NR3_0P8
XU349 n346 n341 SEN_INV_1
XU350 n236 n106 n120 n261 n229 SEN_OA22_DG_1
XU351 n266 n148 n354 SEN_OR2_1
XU352 n267 n44 n351 SEN_OR2_1
XU353 n148 n300 n301 n302 SEN_NR3_T_1
XU354 n354 n340 SEN_INV_S_1
XU355 n268 X[0] n78 SEN_AN2_S_0P5
XU356 n269 n337 X[16] SEN_AN2_S_0P5
XU357 n152 LOG n342 n40 SEN_NR3_0P8
XU358 n270 n316 n117 SEN_AN2_S_0P5
XU359 n271 n349 n321 SEN_AN2_S_0P5
XU360 n272 n347 n110 SEN_AN2_S_1
XU361 n124 n270 n271 n272 SEN_NR3_T_2
XU362 n117 n107 n280 n101 n261 n147 n123 SEN_OAI222_0P75
XU363 n110 n125 n280 n126 n261 n127 n123 SEN_OAI222_1
XU364 Z[3] n41 n354 n71 n351 n124 SEN_OAI221_0P5
XU365 n273 n346 X[13] SEN_AN2_S_0P5
XU366 n274 n246 X[29] SEN_AN2_S_0P5
XU367 n109 n273 n274 SEN_NR2_1
XU368 n246 n212 n342 SEN_NR2_T_0P5
XU369 n147 n69 n247 n53 n248 n109 n173 SEN_OA222_1
XU370 n212 n254 S[4] SEN_EO2_5
XU371 n254 S[3] n253 n342 SEN_OAI21_4
XU372 n276 n193 n317 SEN_NR2_S_0P5
XU373 n277 n155 n280 SEN_NR2_S_0P5
XU374 n278 n194 SEN_INV_S_1
XU375 n183 n276 n277 n278 SEN_OR3_1
XU376 n194 n80 n178 n261 n175 SEN_OA2BB2_0P5
XU377 n230 n261 n120 n106 n193 SEN_OA22_1
XU378 n104 n123 n82 SEN_ND2_S_0P5
XU379 n282 n121 n106 SEN_OR2_DG_1
XU380 n283 n122 n84 SEN_OR2_DG_1
XU381 n146 n282 n283 n249 SEN_ND3_1
XU382 n285 n181 n261 SEN_NR2_S_0P5
XU383 n286 n161 n260 SEN_NR2_S_0P5
XU384 n161 X[2] n78 X[18] n74 n152 SEN_AOI221_1
XU385 n208 n125 n317 n181 n281 n218 SEN_OAI221_0P5
XU386 n92 n126 n317 n203 n280 n239 SEN_OAI221_0P5
XU387 n95 n101 n317 n103 n280 n105 SEN_OAI221_0P5
XU388 n221 n229 n317 n175 n280 n230 SEN_OAI221_0P5
XU389 n97 n112 n317 n113 n280 n114 SEN_OAI221_0P5
XU390 n99 n120 n281 n121 n261 n122 n123 SEN_OAI222_0P5
XU391 n227 n109 n317 n207 n280 n235 SEN_OAI221_1
XU392 n287 n73 n40 SEN_NR2_S_0P5
XU393 n288 n136 n59 SEN_NR2_S_0P5
XU394 n178 n287 n288 n32 SEN_OR3_2
XU395 n73 n345 SEN_INV_S_2
XU396 n40 X[31] SEN_INV_1
XU397 n136 n75 n342 SEN_ND2_G_1
XU398 n216 n152 n75 SEN_ND2_G_1
XU399 n177 n160 X[23] n173 n178 SEN_AOI22_0P75
XU400 n289 n346 X[18] SEN_ND2_G_1
XU401 n290 n336 X[2] SEN_ND2_S_0P5
XU402 n291 n32 SEN_INV_S_0P5
XU403 n125 n289 n290 n291 SEN_AN3_1
XU404 n233 n106 n203 n261 n125 SEN_OA22_DG_1
XU405 n292 n346 X[25] SEN_ND2_S_0P5
XU406 n293 n337 X[9] SEN_ND2_S_0P5
XU407 n207 n292 n293 n291 SEN_AN3_1
XU408 n223 n261 n103 n106 n207 SEN_OAI22_0P5
XU409 n316 n355 SEN_BUF_2
XU410 n102 n84 n173 SEN_ND2_0P5
XU411 n317 n84 n173 SEN_ND2_0P5
XU412 n294 S[1] S[0] SEN_NR2_S_0P5
XU413 n295 n345 X[20] SEN_ND2_S_0P5
XU414 n296 n336 X[4] SEN_ND2_S_0P5
XU415 n297 n32 SEN_INV_S_0P5
XU416 n113 n295 n296 n297 SEN_AN3_1
XU417 n226 n261 n113 n106 n188 SEN_OAI22_S_0P5
XU418 n237 n83 n115 n106 n113 SEN_OA2BB2_DG_1
XU419 n326 n175 n317 SEN_NR2_G_0P5
XU420 n165 n160 X[25] n82 n166 SEN_OA2BB2_0P5
XU421 n173 n324 n325 SEN_ND2_2
XU422 n309 n349 n33 SEN_ND2_0P65
XU423 n334 n348 n33 SEN_ND2_G_1
XU424 Z[25] n168 n354 n48 n351 n169 SEN_OAI221_1
XU425 n303 X[1] n78 SEN_ND2_S_0P5
XU426 n304 n74 X[17] SEN_ND2_S_0P5
XU427 n166 n303 n304 n39 SEN_AN3_1
XU428 n255 S[1] S[0] SEN_NR2_T_2
XU429 n79 n102 SEN_INV_1
XU430 n74 n136 SEN_INV_2
XU431 n153 n305 n306 n307 SEN_AN3_S_1
XU432 n75 n212 SEN_INV_4
XU433 n322 n252 SEN_INV_S_0P5
XU434 n157 n308 n309 n310 SEN_AN3_1
XU435 n169 n332 n333 n334 SEN_AN3_1
XU436 n298 n346 n344 SEN_ND2_S_0P5
XU437 n299 n336 X[8] SEN_ND2_S_0P5
XU438 n188 n298 n299 n291 SEN_AN3_1
XU439 n211 n80 n170 n108 n188 SEN_OA2BB2_0P5
XU440 n300 n164 n79 SEN_AN2_S_0P5
XU441 n301 n144 n80 SEN_AN2_S_1
XU442 n302 n142 n123 SEN_AN2_DG_1
XU443 n144 n69 n137 n331 n53 n39 SEN_OAI221_0P5
XU444 n80 n106 SEN_INV_1
XU445 n345 n341 SEN_INV_2
XU446 n33 n153 SEN_INV_1
XU447 Z[28] n153 n354 n45 n351 n154 SEN_OAI221_1
XU448 n307 n151 n123 SEN_ND2_S_0P5
XU449 n155 X[3] n78 n337 X[19] n152 SEN_AOI221_0P5
XU450 n305 n170 n79 SEN_ND2_S_0P5
XU451 n306 n171 n80 SEN_ND2_S_0P5
XU452 n170 n73 n45 n331 n62 n216 SEN_OAI221_0P5
XU453 n244 n246 n102 SEN_NR2B_V1DG_1
XU454 n347 n339 SEN_INV_S_1
XU455 n323 S[3] SEN_INV_S_0P5
XU456 n253 S[2] n255 SEN_ND2B_V1_3
XU457 n308 n316 n34 SEN_ND2_S_0P5
XU458 n310 n347 n335 SEN_ND2_S_0P5
XU459 n311 n355 n208 SEN_ND2_S_0P5
XU460 n312 n350 n20 SEN_ND2_S_0P5
XU461 n313 n347 n15 SEN_ND2_S_0P5
XU462 n214 n311 n312 n313 SEN_AN3_S_1
XU463 n314 n345 X[23] SEN_ND2_S_0P5
XU464 n315 n336 X[7] SEN_ND2_S_0P5
XU465 n193 n314 n315 n297 SEN_AN3_1
XU466 n90 n121 n317 n193 n280 n236 SEN_OAI221_1
XU467 n128 n140 n130 n141 n130 SEN_OA2BB2_DG_1
XU468 n328 n35 n84 SEN_NR2_S_0P5
XU469 n324 n252 n323 SEN_ND2_S_0P5
XU470 n174 n355 n167 n350 n22 n347 n162 SEN_AOI222_1
XU471 n186 n329 n330 n204 SEN_ND3_S_1
XU472 n248 n246 n173 SEN_ND2_S_0P5
XU473 n247 n345 n173 SEN_ND2_S_0P5
XU474 n200 n70 n247 n54 n248 n116 n173 SEN_OAI222_0P5
XU475 n318 n355 n140 SEN_ND2_S_0P5
XU476 n320 n348 n131 SEN_ND2_G_1
XU477 n122 n67 n247 n51 n248 n229 n173 SEN_OA222_0P5
XU478 n82 n173 SEN_INV_S_0P5
XU479 n181 X[30] n346 X[14] n337 n32 SEN_AOI221_0P5
XU480 n332 n316 n162 SEN_ND2_S_0P5
XU481 n319 n349 n335 SEN_ND2_S_0P5
XU482 n325 n322 S[3] SEN_ND2_2
XU483 n127 n68 n247 n52 n248 n232 n173 SEN_OA222_0P5
XU484 n353 n340 SEN_INV_S_1
XU485 n105 n106 n107 n108 n109 SEN_OA22_DG_1
XU486 n239 n106 n125 n108 n232 SEN_OA22_DG_1
XU487 n189 n83 n170 n80 n37 SEN_AOI22_0P5
XU488 n118 n115 n81 n50 n83 n200 n84 SEN_AOI222_0P5
XU489 n197 n257 n343 SEN_NR2_G_1
XU490 n111 n316 n275 n349 n110 n348 n97 SEN_AOI222_1
XU491 n204 n83 n28 n80 n31 SEN_AOI22_0P5
XU492 n162 n326 n327 n328 SEN_OR3_1
XU493 n245 n147 n84 n101 n106 SEN_OAI22_S_0P5
XU494 n219 n346 X[26] n336 X[10] n32 SEN_AOI221_0P5
XU495 n241 n343 n196 n257 X[0] SEN_AOI22_0P5
XU496 Z[0] n240 n353 n43 n238 n241 SEN_OAI221_0P5
XU497 n35 n176 SEN_INV_1
XU498 n130 n251 S[1] SEN_EO2_S_0P5
XU499 Z[1] n196 n197 n198 n350 n199 SEN_AO221_0P5
XU500 n199 n348 n321 n257 X[1] SEN_AO22_DG_1
XU501 n327 n155 n106 SEN_NR2_S_0P5
XU502 n29 n162 SEN_INV_1
XU503 n187 n355 n183 n350 n186 n347 n179 SEN_AOI222_1
XU504 n206 n83 n23 n80 n164 SEN_AOI22_0P5
XU505 n85 n130 SEN_INV_S_0P5
XU506 n5 n186 SEN_INV_S_0P5
XU507 n138 n31 n79 n133 n80 n135 n123 SEN_AOI222_0P5
XU508 n17 n120 SEN_INV_S_0P5
XU509 n141 n84 n142 n81 n143 n83 n144 SEN_AOI222_0P5
XU510 n143 n61 n137 n331 n44 n39 SEN_OAI221_0P5
XU511 n24 n107 SEN_INV_1
XU512 n50 n112 SEN_INV_1
XU513 n339 n86 n130 SEN_OR2_DG_1
XU514 n335 n31 n79 n133 n80 n135 n123 SEN_AO222_1
XU515 n229 n346 X[15] n246 X[31] SEN_AOI22_0P5
XU516 n329 n203 n317 SEN_OR2_DG_1
XU517 n330 n161 n281 SEN_OR2_DG_1
XU518 n331 n74 SEN_INV_S_6
XU519 n243 n102 n73 SEN_NR2_S_0P5
XU520 n22 n168 SEN_INV_1
XU521 n20 n209 SEN_INV_2
XU522 n15 n201 SEN_INV_2
XU523 n8 n213 SEN_INV_2
XU524 n160 n331 n173 SEN_NR2_S_0P5
XU525 n164 n73 n44 n331 n61 n216 SEN_OAI221_0P5
XU526 n171 n70 n137 n331 n54 n39 SEN_OAI221_0P5
XU527 n168 n23 n79 n144 n81 n185 SEN_AOI221_1
XU528 n21 n191 SEN_INV_S_0P5
XU529 n2 n92 SEN_INV_S_0P5
XU530 n16 n183 SEN_INV_S_0P5
XU531 n7 n94 SEN_INV_S_0P5
XU532 n14 n221 SEN_INV_S_0P5
XU533 n6 n110 SEN_INV_S_0P5
XU534 n10 n179 SEN_INV_S_0P5
XU535 n25 n117 SEN_INV_S_0P5
XU536 n19 n227 SEN_INV_S_0P5
XU537 n3 n224 SEN_INV_S_0P5
XU538 n26 n95 SEN_INV_S_0P5
XU539 n12 n97 SEN_INV_S_0P5
XU540 n41 n146 SEN_INV_1
XU541 n37 n190 SEN_INV_1
XU542 n341 n75 n342 SEN_OR2_DG_1
XU543 n150 X[28] n337 n78 X[12] n152 SEN_AOI221_0P5
XU544 n36 n151 SEN_INV_S_0P5
XU545 n140 n155 n261 n156 n281 n35 n123 SEN_OAI222_0P5
XU546 n156 X[27] n336 n78 X[11] n152 SEN_AOI221_0P5
XU547 n251 n343 n342 SEN_ND2_S_0P5
XU548 n27 n167 SEN_INV_S_0P5
XU549 n116 n345 X[12] n246 X[28] SEN_AOI22_0P5
XU550 n198 n126 n260 n127 n84 n250 SEN_OAI221_0P5
XU551 n232 n345 X[14] n246 X[30] SEN_AOI22_0P5
XU552 n121 n345 X[11] n246 X[27] SEN_AOI22_0P5
XU553 n126 n346 X[10] n246 X[26] SEN_AOI22_0P5
XU554 n101 n345 X[9] n246 X[25] SEN_AOI22_0P5
XU555 n112 n346 X[8] n246 n344 SEN_AOI22_0P5
XU556 n115 n345 X[16] n337 X[0] n32 SEN_AO221_0P5
XU557 n4 n208 SEN_INV_S_0P5
XU558 n240 n123 n200 n244 X[16] n80 n50 SEN_AOI222_0P5
XU559 n342 LEFT SEN_BUF_6
XU560 n142 n65 n158 n39 n165 SEN_OAI211_1
XU561 n343 S[0] SEN_BUF_1
XU562 n31 n181 SEN_INV_1
XU563 n350 n338 SEN_INV_S_1
XU564 n38 n171 SEN_INV_S_1
XU565 n338 n85 n86 SEN_OR2_1
XU566 n238 n197 n85 SEN_ND2_G_1
XU567 n348 n339 SEN_INV_S_1
XU568 n179 n188 n317 n38 n281 n189 SEN_OAI221_1
XU569 n218 n80 n28 n261 n203 SEN_OA2BB2_1
XU570 n191 n103 n317 n166 n281 n206 SEN_OAI221_1
XU571 n224 n232 n317 n219 n280 n233 SEN_OAI221_1
XU572 n114 n80 n115 n108 n116 SEN_OA2BB2_1
XU573 n133 n68 n137 n331 n52 n39 SEN_OAI221_1
XU574 Z[31] n343 n128 n129 n86 n40 n351 SEN_OAI222_1
XU575 n134 n331 n42 n137 n60 n39 SEN_OAI221_0P5
XU576 Z[4] n118 n354 n70 n351 n119 SEN_OAI221_1
XU577 n119 n316 n110 n349 n117 n348 n275 SEN_AOI222_1
XU578 Z[30] n138 n354 n42 n351 n139 SEN_OAI221_1
XU579 n139 n316 n131 n86 n128 SEN_OA2BB2_1
XU580 n154 n316 n335 n349 n34 n348 n140 SEN_AOI222_1
XU581 Z[6] n6 n354 n68 n351 n100 SEN_OAI221_1
XU582 n100 n316 n97 n349 n275 n348 n95 SEN_AOI222_1
XU583 Z[7] n18 n354 n67 n351 n98 SEN_OAI221_1
XU584 n18 n275 SEN_INV_S_1
XU585 n98 n316 n95 n349 n97 n348 n92 SEN_AOI222_1
XU586 Z[5] n25 n354 n69 n351 n111 SEN_OAI221_1
XU587 n28 n219 SEN_INV_1
XU588 Z[24] n10 n354 n49 n352 n174 SEN_OAI221_1
XU589 n49 n344 SEN_INV_S_1
XU590 Z[9] n26 n353 n65 n352 n89 SEN_OAI221_1
XU591 n89 n355 n90 n350 n92 n347 n94 SEN_AOI222_1
XU592 Z[10] n2 n353 n64 n351 n234 SEN_OAI221_1
XU593 n234 n316 n94 n349 n90 n348 n227 SEN_AOI222_1
XU594 Z[20] n284 n353 n54 n352 n192 SEN_OAI221_1
XU595 n192 n355 n186 n350 n191 n347 n183 SEN_AOI222_1
XU596 Z[21] n21 n353 n53 n352 n187 SEN_OAI221_1
XU597 Z[23] n16 n354 n51 n352 n180 SEN_OAI221_1
XU598 n180 n355 n22 n350 n179 n347 n167 SEN_AOI222_1
XU599 Z[12] n7 n353 n62 n352 n228 SEN_OAI221_1
XU600 n228 n316 n224 n349 n227 n348 n221 SEN_AOI222_1
XU601 Z[13] n19 n353 n61 n352 n225 SEN_OAI221_1
XU602 n225 n355 n221 n350 n224 n347 n8 SEN_AOI222_1
XU603 Z[14] n3 n353 n60 n352 n222 SEN_OAI221_1
XU604 n222 n355 n8 n350 n221 n347 n20 SEN_AOI222_1
XU605 Z[15] n14 n353 n59 n352 n217 SEN_OAI221_1
XU606 n217 n355 n20 n350 n8 n347 n208 SEN_AOI222_1
XU607 Z[22] n5 n353 n52 n352 n184 SEN_OAI221_1
XU608 Z[8] n12 n354 n66 n351 n96 SEN_OAI221_1
XU609 n96 n316 n92 n349 n95 n348 n90 SEN_AOI222_1
XU610 n86 n343 SEN_INV_S_1
XU611 n43 n198 SEN_INV_S_1
XU612 n107 n345 X[17] n336 X[1] n32 SEN_AOI221_1
XU613 n249 n243 X[3] n244 X[19] SEN_AOI22_1
XU614 n159 n160 X[26] n82 n161 SEN_OA2BB2_1
XU615 n250 n243 X[2] n244 X[18] SEN_AOI22_1
XU616 n252 n342 n253 SEN_ND2_S_0P5
XU617 Z[16] n213 n353 n58 n352 n214 SEN_OAI221_1
XU618 n58 X[16] SEN_INV_S_1
XU619 Z[17] n209 n353 n57 n352 n210 SEN_OAI221_1
XU620 n57 X[17] SEN_INV_S_1
XU621 n210 n355 n15 n350 n208 n347 n195 SEN_AOI222_1
XU622 n196 n41 n130 n242 n85 SEN_OAI22_1
XU623 n242 n243 X[1] n244 X[17] n245 SEN_AOI221_1
XU624 n48 X[25] SEN_INV_S_1
XU625 Z[19] n201 n353 n55 n352 n202 SEN_OAI221_1
XU626 n55 X[19] SEN_INV_S_1
XU627 n202 n355 n191 n350 n195 n347 n186 SEN_AOI222_1
XU628 Z[27] n29 n354 n46 n351 n157 SEN_OAI221_1
XU629 n46 X[27] SEN_INV_S_1
XU630 n71 X[3] SEN_INV_S_1
XU631 Z[18] n4 n353 n56 n352 n205 SEN_OAI221_1
XU632 n56 X[18] SEN_INV_S_1
XU633 n205 n355 n195 n350 n15 n347 n191 SEN_AOI222_1
XU634 Z[11] n13 n353 n63 n352 n231 SEN_OAI221_1
XU635 n63 X[11] SEN_INV_S_1
XU636 n13 n90 SEN_INV_S_1
XU637 n231 n316 n227 n349 n94 n348 n224 SEN_AOI222_1
XU638 Z[26] n27 n354 n47 n351 n163 SEN_OAI221_1
XU639 n47 X[26] SEN_INV_S_1
XU640 n163 n316 n33 n349 n162 n348 n34 SEN_AOI222_1
XU641 Z[2] n43 n354 n72 n351 n145 SEN_OAI221_1
XU642 n72 X[2] SEN_INV_S_1
XU643 n145 n316 n321 n349 n146 n348 n117 SEN_AOI222_1
XU644 n45 X[28] SEN_INV_S_1
XU645 n42 X[30] SEN_INV_S_1
XU646 n44 X[29] SEN_INV_S_1
XU647 n62 X[12] SEN_INV_S_1
XU648 n60 X[14] SEN_INV_S_1
XU649 n65 X[9] SEN_INV_S_1
XU650 n66 X[8] SEN_INV_S_1
XU651 n64 X[10] SEN_INV_S_1
XU652 n61 X[13] SEN_INV_S_1
XU653 n51 X[23] SEN_INV_S_1
XU654 n54 X[20] SEN_INV_S_1
XU655 n70 X[4] SEN_INV_S_1
XU656 n53 X[21] SEN_INV_S_1
XU657 n52 X[22] SEN_INV_S_1
XU658 n59 X[15] SEN_INV_S_1
XU659 n67 X[7] SEN_INV_S_1
XU660 n69 X[5] SEN_INV_S_1
XU661 n68 X[6] SEN_INV_S_1
XU662 n176 n67 n158 n39 n177 SEN_OAI211_1
XU663 n344 X[24] SEN_BUF_S_1
.ENDS
.GLOBAL VDD
.GLOBAL VSS
