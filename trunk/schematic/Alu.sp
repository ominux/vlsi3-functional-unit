.inc /usr/nikola/groups/vlsi/data/cmos10lpe/IBM_PDK/cmos10lpe/relCP/HSPICE/models/design.inc
.inc ./cp65npksdst.extracted

$ Spice netlist generated by v2lvs
$ v2007.1_31.29    Wed Apr  4 12:35:05 PDT 2007

.SUBCKT Alu Z[31] Z[30] Z[29] Z[28] Z[27] Z[26] Z[25] Z[24] Z[23] Z[22] Z[21]
+ Z[20] Z[19] Z[18] Z[17] Z[16] Z[15] Z[14] Z[13] Z[12] Z[11] Z[10] Z[9] Z[8]
+ Z[7] Z[6] Z[5] Z[4] Z[3] Z[2] Z[1] Z[0] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31]
+ B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18]
+ B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4]
+ B[3] B[2] B[1] B[0] INST[3] INST[2] INST[1] INST[0] FLAGS[3] FLAGS[2]
+ FLAGS[1] FLAGS[0]
*.CONNECT FLAGS[3] *Logic0*
*.CONNECT Z[6] net3712
*.CONNECT Z[7] net3715
*.CONNECT Z[8] net3718
*.CONNECT Z[9] net3721
*.CONNECT Z[31] net3724
*.CONNECT Z[3] net3727
*.CONNECT Z[4] net3730
*.CONNECT Z[5] net3733
*.CONNECT Z[28] net3736
*.CONNECT Z[29] net3739
*.CONNECT Z[2] net3742
*.CONNECT Z[30] net3745
*.CONNECT Z[24] net3748
*.CONNECT Z[25] net3751
*.CONNECT Z[26] net3754
*.CONNECT Z[27] net3757
XU471 SEN_ND2_3 $PINS A1=net16476 A2=n619 X=n780
XU472 SEN_ND2_T_1 $PINS A1=n472 A2=n473 X=n474
XU473 SEN_ND2_G_1 $PINS A1=net16482 A2=n471 X=n472
XU474 SEN_ND2_S_2 $PINS A1=n641 A2=n554 X=n647
XU475 SEN_AOAI211_6 $PINS A1=n543 A2=n667 B=n666 C=n848 X=n855
XU476 SEN_OAI21_T_4 $PINS A1=n533 A2=n847 B=n532 X=n666
XU477 SEN_INV_AS_5 $PINS A=n838 X=n667
XU478 SEN_INV_1 $PINS A=n746 X=n847
XU479 SEN_ND2_2 $PINS A1=n662 A2=n663 X=n746
XU480 SEN_NR2_T_5 $PINS A1=n772 A2=net15882 X=n610
XU481 SEN_ND2_T_5 $PINS A1=n360 A2=n527 X=n643
XU482 SEN_INV_S_3 $PINS A=n638 X=n818
XU483 SEN_INV_4 $PINS A=n855 X=n672
XU484 SEN_INV_3 $PINS A=n665 X=n843
XU485 SEN_ND2_G_1 $PINS A1=n649 A2=n648 X=n759
XU486 SEN_OAI21_2 $PINS A1=n703 A2=net16400 B=n558 X=n559
XU487 SEN_INV_4 $PINS A=n557 X=n703
XU488 SEN_INV_4 $PINS A=n698 X=n552
XU489 SEN_ND2_1P5 $PINS A1=n690 A2=n885 X=n691
XU490 SEN_ND2_S_6 $PINS A1=net15941 A2=net15940 X=n397
XU491 SEN_OAI211_2 $PINS A1=net15884 A2=net16410 B1=net15885 B2=net15886
+ X=net3721
XU492 SEN_EN2_S_2 $PINS A1=n523 A2=n824 X=net15884
XU493 SEN_INV_S_6 $PINS A=n651 X=n358
XU494 SEN_ND2_T_4 $PINS A1=n635 A2=n554 X=n651
XU495 SEN_INV_S_0P5 $PINS A=n651 X=n835
XU496 SEN_ND2_T_0P5 $PINS A1=net16085 A2=net16152 X=n454
XU497 SEN_ND2_G_4 $PINS A1=n455 A2=n456 X=n533
XU498 SEN_MUXI2_DG_2 $PINS D0=net16480 D1=net16669 S=A[17] X=n593
XU499 SEN_INV_5 $PINS A=net16499 X=net16311
XU500 SEN_AN3_0P5 $PINS A1=net16311 A2=n703 A3=net16501 X=n359
XU501 SEN_OAI211_3 $PINS A1=net15785 A2=net16410 B1=net15786 B2=net15787
+ X=Z[23]
XU502 SEN_OAI211_2 $PINS A1=net16144 A2=net16410 B1=net16145 B2=net16146
+ X=net3751
XU503 SEN_OAI21B_4 $PINS A1=net16113 A2=net16410 B=n386 X=net3739
XU504 SEN_OR3_8 $PINS A1=net16281 A2=net16282 A3=net17773 X=net15916
XU505 SEN_ND2_2 $PINS A1=n463 A2=n464 X=n884
XU506 SEN_INV_S_2 $PINS A=net16336 X=net16010
XU507 SEN_AOI31_4 $PINS A1=n737 A2=n885 A3=n736 B=n735 X=n738
XU508 SEN_INV_1 $PINS A=net15897 X=net15881
XU509 SEN_OAI21_G_4 $PINS A1=n870 A2=n869 B=n868 X=n871
XU510 SEN_ND2_T_1 $PINS A1=n553 A2=n587 X=n668
XU511 SEN_ND2_3 $PINS A1=net16474 A2=n628 X=net16289
XU512 SEN_MUXI2_S_3 $PINS D0=net16482 D1=n549 S=A[2] X=n628
XU513 SEN_INV_S_3 $PINS A=net16015 X=net16281
XU514 SEN_NR3_T_4 $PINS A1=net16284 A2=net15985 A3=net16287 X=net16293
XU515 SEN_ND2_S_6 $PINS A1=n505 A2=n506 X=net15985
XU516 SEN_INV_6 $PINS A=n504 X=n549
XU517 SEN_INV_2 $PINS A=n758 X=n834
XU518 SEN_NR2_G_2 $PINS A1=n534 A2=n758 X=n653
XU519 SEN_AOI211_G_5 $PINS A1=n771 A2=n370 B1=n610 B2=n770 X=n611
XU520 SEN_INV_4 $PINS A=n369 X=n370
XU521 SEN_BUF_8 $PINS A=INST[1] X=net16499
XU522 SEN_ND2_T_1 $PINS A1=net16501 A2=net16499 X=n704
XU523 SEN_INV_1P25 $PINS A=n512 X=n511
XU524 SEN_ND2_2 $PINS A1=net16495 A2=net16499 X=n394
XU525 SEN_INV_4 $PINS A=n620 X=n782
XU526 SEN_ND2_G_3 $PINS A1=n489 A2=n561 X=net15769
XU527 SEN_ND2_S_3 $PINS A1=n791 A2=n786 X=n376
XU528 SEN_ND2_1P5 $PINS A1=n787 A2=n786 X=n792
XU529 SEN_NR2_T_1 $PINS A1=net16497 A2=net16501 X=n561
XU530 SEN_INV_S_2 $PINS A=net3715 X=n428
XU531 SEN_ND2_T_2 $PINS A1=n554 A2=n614 X=n617
XU532 SEN_MUXI2_S_3 $PINS D0=net16482 D1=net16669 S=A[4] X=n396
XU533 SEN_INV_6 $PINS A=net16200 X=net16486
XU534 SEN_INV_3 $PINS A=Z[17] X=n381
XU535 SEN_OAI211_4 $PINS A1=net15760 A2=net16412 B1=net15762 B2=net15763
+ X=net3757
XU536 SEN_ND3_T_2 $PINS A1=n797 A2=net15973 A3=n796 X=n799
XU537 SEN_ND2_6 $PINS A1=n396 A2=net16476 X=net16292
XU538 SEN_INV_5 $PINS A=n490 X=n491
XU539 SEN_INV_2 $PINS A=n512 X=n518
XU540 SEN_EN2_8 $PINS A1=n811 A2=n810 X=n878
XU541 SEN_ND2_4 $PINS A1=n548 A2=n547 X=net15760
XU542 SEN_INV_2 $PINS A=net15915 X=n360
XU543 SEN_INV_4 $PINS A=net15915 X=net16057
XU544 SEN_ND2_G_1 $PINS A1=net17648 A2=net16298 X=net16014
XU545 SEN_INV_2 $PINS A=n544 X=n767
XU546 SEN_INV_S_1P5 $PINS A=n632 X=n768
XU547 SEN_ND2_S_6 $PINS A1=net15945 A2=net15946 X=net15961
XU548 SEN_INV_4 $PINS A=net16292 X=net15940
XU549 SEN_EN2_S_4 $PINS A1=net16010 A2=net16009 X=n771
XU550 SEN_ND2_T_2 $PINS A1=n508 A2=n509 X=n510
XU551 SEN_AOI222_1 $PINS A1=n451 A2=n742 B1=net17584 B2=n374 C1=n741 C2=n740
+ X=net16087
XU552 SEN_NR2_T_5 $PINS A1=n560 A2=n499 X=n451
XU553 SEN_MUXI2_S_4 $PINS D0=net16480 D1=net16669 S=A[7] X=n603
XU554 SEN_ND2_T_3 $PINS A1=net15916 A2=net16062 X=net15865
XU555 SEN_INV_S_8 $PINS A=net16486 X=net16480
XU556 SEN_MUXI2_S_4 $PINS D0=n550 D1=n493 S=B[7] X=n602
XU557 SEN_OAI211_3 $PINS A1=net16028 A2=net16412 B1=net16029 B2=net16030
+ X=Z[11]
XU558 SEN_EN2_5 $PINS A1=net16021 A2=net16020 X=n770
XU559 SEN_ND2_T_6 $PINS A1=n878 A2=net17669 X=n838
XU560 SEN_INV_S_3 $PINS A=net15784 X=net17668
XU561 SEN_ND2_3 $PINS A1=n660 A2=n361 X=net15784
XU562 SEN_ND2_T_4 $PINS A1=n554 A2=n604 X=n607
XU563 SEN_ND2_T_5 $PINS A1=n804 A2=net17656 X=n772
XU564 SEN_ND2_S_1P5 $PINS A1=n537 A2=n885 X=n547
XU565 SEN_INV_AS_10 $PINS A=net16486 X=net16482
XU566 SEN_INV_3 $PINS A=n649 X=n755
XU567 SEN_ND2_T_2 $PINS A1=n662 A2=n881 X=n456
XU568 SEN_INV_1P25 $PINS A=n663 X=n881
XU569 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n539 X=n883
XU570 SEN_OA21_4 $PINS A1=n884 A2=net16410 B=n883 X=net17713
XU571 SEN_OAI21_2 $PINS A1=n521 A2=net15882 B=n821 X=n822
XU572 SEN_NR2_S_1 $PINS A1=net15881 A2=net15882 X=n823
XU573 SEN_NR3_T_0P8 $PINS A1=net15881 A2=net15882 A3=net15883 X=n826
XU574 SEN_ND3_T_1 $PINS A1=net15880 A2=net15894 A3=n370 X=n401
XU575 SEN_INV_5 $PINS A=n370 X=net15882
XU576 SEN_ND2_T_2 $PINS A1=net16336 A2=net16337 X=net16322
XU577 SEN_MUXI2_S_4 $PINS D0=n551 D1=n493 S=B[4] X=n629
XU578 SEN_INV_5 $PINS A=n512 X=n493
XU579 SEN_OA21_4 $PINS A1=n758 A2=n759 B=n760 X=n652
XU580 SEN_ND2_G_0P65 $PINS A1=n680 A2=n681 X=net16153
XU581 SEN_INV_S_2 $PINS A=n680 X=n743
XU582 SEN_ND2_G_2 $PINS A1=net16311 A2=net16495 X=n488
XU583 SEN_ND2_G_1 $PINS A1=net17602 A2=n597 X=n361
XU584 SEN_ND2_2 $PINS A1=net17602 A2=n597 X=n661
XU585 SEN_MUXI2_S_2 $PINS D0=net16480 D1=net16669 S=A[16] X=n597
XU586 SEN_INV_2 $PINS A=net15985 X=net15973
XU587 SEN_ND2_T_4 $PINS A1=n787 A2=n377 X=n796
XU588 SEN_AN2_DG_2 $PINS A1=net16291 A2=net16292 X=net16949
XU589 SEN_BUF_1 $PINS A=n847 X=n362
XU590 SEN_INV_4 $PINS A=n606 X=n807
XU591 SEN_ND2_T_4 $PINS A1=net17602 A2=n605 X=n606
XU592 SEN_INV_S_6 $PINS A=n607 X=n806
XU593 SEN_INV_8 $PINS A=n504 X=n683
XU594 SEN_NR2B_V1_8 $PINS A=net16179 B=net17414 X=n504
XU595 SEN_EO2_6 $PINS A1=net16300 A2=net15967 X=net15945
XU596 SEN_ND2_S_2 $PINS A1=net16985 A2=n816 X=n459
XU597 SEN_ND2_G_1 $PINS A1=net16311 A2=net16408 X=net16407
XU598 SEN_INV_2 $PINS A=n622 X=n781
XU599 SEN_NR2_S_4 $PINS A1=n780 A2=n781 X=n623
XU600 SEN_NR3_T_6 $PINS A1=n388 A2=net3757 A3=n414 X=n412
XU601 SEN_INV_3 $PINS A=n611 X=n450
XU602 SEN_EN2_S_6 $PINS A1=n737 A2=n722 X=net16113
XU603 SEN_OAI211_3 $PINS A1=net16123 A2=n719 B1=net16125 B2=n736 X=n720
XU604 SEN_ND2_T_2 $PINS A1=net16476 A2=n615 X=n616
XU605 SEN_INV_3 $PINS A=n376 X=n377
XU606 SEN_ND2_2 $PINS A1=n617 A2=n616 X=n791
XU607 SEN_ND2_S_4 $PINS A1=n409 A2=n410 X=n405
XU608 SEN_INV_2P5 $PINS A=n661 X=n811
XU609 SEN_INV_4 $PINS A=n556 X=n553
XU610 SEN_ND2_S_4 $PINS A1=n592 A2=n553 X=n662
XU611 SEN_ND2_T_2 $PINS A1=n553 A2=n590 X=n664
XU612 SEN_ND2_S_4 $PINS A1=n415 A2=n416 X=n414
XU613 SEN_MUXI2_DG_2 $PINS D0=net16482 D1=net16669 S=A[11] X=n631
XU614 SEN_OAI211_3 $PINS A1=net15830 A2=net16410 B1=net15831 B2=net15832
+ X=Z[19]
XU615 SEN_ND2_S_3 $PINS A1=n554 A2=n612 X=net16299
XU616 SEN_MUXI2_DG_3 $PINS D0=n551 D1=n518 S=B[5] X=n612
XU617 SEN_INV_S_4 $PINS A=n498 X=n499
XU618 SEN_ND2B_V1_2 $PINS A=net16501 B=net16495 X=n560
XU619 SEN_OAI21_5 $PINS A1=net16086 A2=net16410 B=net16087 X=net3745
XU620 SEN_ND2_6 $PINS A1=n384 A2=n385 X=n532
XU621 SEN_NR2_S_3 $PINS A1=net16311 A2=net16497 X=n498
XU622 SEN_ND2_T_4 $PINS A1=n626 A2=net17602 X=net16301
XU623 SEN_ND2_S_0P5 $PINS A1=n855 A2=n856 X=n867
XU624 SEN_OAI21_S_1P5 $PINS A1=n531 A2=net18184 B=net15946 X=n803
XU625 SEN_INV_4 $PINS A=n650 X=n836
XU626 SEN_ND3_S_8 $PINS A1=n420 A2=n421 A3=n422 X=n419
XU627 SEN_ND2_T_2 $PINS A1=n518 A2=B[18] X=n478
XU628 SEN_OAI21_G_2 $PINS A1=n875 A2=net15794 B=net15795 X=n876
XU629 SEN_INV_S_1 $PINS A=net15961 X=net15960
XU630 SEN_ND2_3 $PINS A1=net16288 A2=net17420 X=n506
XU631 SEN_INV_4 $PINS A=net15979 X=net17420
XU632 SEN_ND2_T_2 $PINS A1=net16476 A2=n593 X=n663
XU633 SEN_AN3_4 $PINS A1=net17564 A2=n703 A3=net16501 X=net18229
XU634 SEN_ND2_S_6 $PINS A1=n846 A2=n371 X=n864
XU635 SEN_INV_AS_10 $PINS A=n839 X=n846
XU636 SEN_EO2_1 $PINS A1=n809 A2=n519 X=net15919
XU637 SEN_OAI21_5 $PINS A1=n675 A2=n747 B=n522 X=net16073
XU638 SEN_INV_S_4 $PINS A=net16291 X=net15941
XU639 SEN_EN2_S_3 $PINS A1=n860 A2=n861 X=n865
XU640 SEN_INV_S_3 $PINS A=n670 X=n860
XU641 SEN_INV_2 $PINS A=n799 X=n800
XU642 SEN_ND2_4 $PINS A1=n476 A2=n477 X=net16064
XU643 SEN_INV_S_6 $PINS A=net3745 X=n413
XU644 SEN_ND2_S_4 $PINS A1=n618 A2=n554 X=n620
XU645 SEN_INV_S_2 $PINS A=n580 X=n886
XU646 SEN_BUF_1 $PINS A=n499 X=n363
XU647 SEN_EN2_3 $PINS A1=n522 A2=n871 X=net15799
XU648 SEN_NR3_T_3 $PINS A1=net3742 A2=Z[0] A3=Z[1] X=n433
XU649 SEN_OAI211_1 $PINS A1=net15995 A2=net16412 B1=net15996 B2=net15997 X=Z[0]
XU650 SEN_EO2_1 $PINS A1=n782 A2=n783 X=n524
XU651 SEN_INV_1P25 $PINS A=net16497 X=net16408
XU652 SEN_ND2_T_4 $PINS A1=net16501 A2=net16309 X=net16179
XU653 SEN_INV_10 $PINS A=n556 X=n554
XU654 SEN_INV_S_8 $PINS A=n700 X=n556
XU655 SEN_INV_0P5 $PINS A=n771 X=n778
XU656 SEN_ND2_4 $PINS A1=net16293 A2=n797 X=net17189
XU657 SEN_AOI211_G_2 $PINS A1=n800 A2=net15956 B1=net16949 B2=net15958 X=n801
XU658 SEN_AN2_S_1P5 $PINS A1=n492 A2=n752 X=n534
XU659 SEN_ND2_T_1 $PINS A1=n749 A2=net17000 X=n476
XU660 SEN_ND2_3 $PINS A1=n563 A2=net16395 X=net16200
XU661 SEN_EO2_DG_1 $PINS A1=n781 A2=n524 X=net15995
XU662 SEN_OAOI211_4 $PINS A1=n441 A2=n442 B=net17035 C=net16143 X=n440
XU663 SEN_INV_1 $PINS A=net16337 X=net16009
XU664 SEN_MUXI2_S_6 $PINS D0=n551 D1=n493 S=B[6] X=n604
XU665 SEN_OAI211_4 $PINS A1=net16051 A2=net16412 B1=net16052 B2=net16053
+ X=Z[12]
XU666 SEN_INV_2P5 $PINS A=n512 X=n494
XU667 SEN_ND2_T_3 $PINS A1=net16127 A2=net16154 X=n441
XU668 SEN_INV_0P65 $PINS A=n512 X=n368
XU669 SEN_INV_2 $PINS A=n512 X=n517
XU670 SEN_NR3_T_6 $PINS A1=Z[12] A2=n445 A3=Z[14] X=n420
XU671 SEN_ND2_S_2 $PINS A1=net16015 A2=net16014 X=n820
XU672 SEN_AN2_S_1 $PINS A1=n778 A2=n375 X=n521
XU673 SEN_ND2_S_1 $PINS A1=n804 A2=net17656 X=n375
XU674 SEN_ND2B_V1_4 $PINS A=n556 B=n629 X=net16291
XU675 SEN_INV_3 $PINS A=net15897 X=net16282
XU676 SEN_ND2_2 $PINS A1=n494 A2=B[2] X=n502
XU677 SEN_ND2_T_2 $PINS A1=n502 A2=n501 X=n503
XU678 SEN_AOAI211_2 $PINS A1=n526 A2=n823 B=n822 C=net15894 X=n824
XU679 SEN_ND2_2 $PINS A1=n673 A2=n674 X=net16074
XU680 SEN_EN2_S_4 $PINS A1=n755 A2=n756 X=net15915
XU681 SEN_INV_3 $PINS A=n832 X=n654
XU682 SEN_ND2_G_1 $PINS A1=net16191 A2=net16192 X=net16154
XU683 SEN_ND2_T_2 $PINS A1=net16125 A2=n719 X=n689
XU684 SEN_ND2_T_4 $PINS A1=n383 A2=n843 X=n385
XU685 SEN_INV_S_4 $PINS A=n664 X=n842
XU686 SEN_ND2_T_1 $PINS A1=n554 A2=n633 X=n656
XU687 SEN_ND2_T_2 $PINS A1=n554 A2=n639 X=n649
XU688 SEN_ND2_S_4 $PINS A1=n625 A2=n554 X=net16300
XU689 SEN_AO21B_1 $PINS A1=n867 A2=n866 B=n859 X=n869
XU690 SEN_ND2_2 $PINS A1=net16291 A2=net16292 X=net17550
XU691 SEN_ND2_6 $PINS A1=n397 A2=net17550 X=net16287
XU692 SEN_INV_1P25 $PINS A=n647 X=n828
XU693 SEN_ND2_T_1 $PINS A1=n647 A2=n646 X=n752
XU694 SEN_EN2_S_3 $PINS A1=net17005 A2=n876 X=net15785
XU695 SEN_INV_S_3 $PINS A=n617 X=n788
XU696 SEN_INV_4 $PINS A=net16284 X=net15953
XU697 SEN_INV_S_6 $PINS A=net3739 X=n410
XU698 SEN_INV_0P8 $PINS A=n718 X=n736
XU699 SEN_INV_3 $PINS A=n444 X=n445
XU700 SEN_INV_S_2 $PINS A=n785 X=n793
XU701 SEN_OAI211_4 $PINS A1=net15927 A2=net16412 B1=net15928 B2=net15929
+ X=net3712
XU702 SEN_ND2_S_4 $PINS A1=net17804 A2=net16018 X=net3718
XU703 SEN_ND2_8 $PINS A1=n380 A2=net15880 X=n751
XU704 SEN_INV_2 $PINS A=net16328 X=net16020
XU705 SEN_ND2_T_2 $PINS A1=n609 A2=net17602 X=net16328
XU706 SEN_MUXI2_DG_2 $PINS D0=net16482 D1=n683 S=A[8] X=n609
XU707 SEN_AO21B_2 $PINS A1=n441 A2=net16084 B=net16153 X=n711
XU708 SEN_EN2_3 $PINS A1=n743 A2=n744 X=net16152
XU709 SEN_INV_2P5 $PINS A=net16152 X=net16084
XU710 SEN_INV_6 $PINS A=net16177 X=net16361
XU711 SEN_INV_S_4 $PINS A=net3718 X=n430
XU712 SEN_ND2_S_2 $PINS A1=net16084 A2=net17843 X=n453
XU713 SEN_INV_S_4 $PINS A=n637 X=n817
XU714 SEN_ND2_S_3 $PINS A1=n555 A2=n594 X=n637
XU715 SEN_INV_6 $PINS A=net16287 X=net15942
XU716 SEN_INV_S_0P5 $PINS A=net17668 X=n364
XU717 SEN_INV_S_0P5 $PINS A=net17668 X=n365
XU718 SEN_INV_4 $PINS A=net17668 X=net17669
XU719 SEN_INV_S_3 $PINS A=net16322 X=n369
XU720 SEN_NR2_T_1P5 $PINS A1=n530 A2=n765 X=n495
XU721 SEN_AOAI211_G_2 $PINS A1=n526 A2=n826 B=n380 C=net15880 X=n827
XU722 SEN_ND2_T_6 $PINS A1=n457 A2=n523 X=n380
XU723 SEN_EO2_S_3 $PINS A1=n742 A2=n738 X=net16086
XU724 SEN_ND2_T_6 $PINS A1=n514 A2=n689 X=n885
XU725 SEN_NR2_T_4 $PINS A1=net17788 A2=n470 X=n514
XU726 SEN_MUXI2_S_1 $PINS D0=n551 D1=n367 S=B[26] X=n687
XU727 SEN_MUX2_DG_1 $PINS D0=n512 D1=n552 S=n541 X=n635
XU728 SEN_MUXI2_S_3 $PINS D0=net16482 D1=n683 S=A[1] X=n615
XU729 SEN_OAI211_3 $PINS A1=net15799 A2=net16410 B1=net15800 B2=net15801
+ X=Z[21]
XU730 SEN_OR2_5 $PINS A1=net18229 A2=n497 X=n513
XU731 SEN_INV_0P65 $PINS A=net15914 X=net15913
XU732 SEN_ND2_T_8 $PINS A1=net15796 A2=net16077 X=n839
XU733 SEN_ND2_8 $PINS A1=net15914 A2=net16985 X=net15796
XU734 SEN_EO2_G_2 $PINS A1=net15973 A2=n794 X=net15975
XU735 SEN_EN2_3 $PINS A1=n852 A2=n853 X=n845
XU736 SEN_INV_S_2 $PINS A=n668 X=n852
XU737 SEN_ND2_6 $PINS A1=n553 A2=n596 X=n660
XU738 SEN_INV_3 $PINS A=net3754 X=n407
XU739 SEN_INV_4 $PINS A=n510 X=n596
XU740 SEN_EN2_6 $PINS A1=net17648 A2=net16298 X=net16284
XU741 SEN_ND3_T_1P5 $PINS A1=n389 A2=net16968 A3=net17573 X=net16395
XU742 SEN_MUXI2_S_3 $PINS D0=n551 D1=n517 S=B[12] X=n639
XU743 SEN_INV_0P8 $PINS A=net16085 X=net17843
XU744 SEN_EO2_5 $PINS A1=n623 A2=n624 X=n787
XU745 SEN_OAI21_S_3 $PINS A1=n519 A2=n378 B=n364 X=n879
XU746 SEN_NR2_2 $PINS A1=net15797 A2=n362 X=n850
XU747 SEN_INV_S_4 $PINS A=Z[22] X=n417
XU748 SEN_EN2_3 $PINS A1=n360 A2=n754 X=net16051
XU749 SEN_OAI211_4 $PINS A1=net16064 A2=net16412 B1=net16065 B2=net16066
+ X=Z[22]
XU750 SEN_OR2_2P5 $PINS A1=n495 A2=n496 X=n754
XU751 SEN_INV_S_2 $PINS A=n494 X=n366
XU752 SEN_INV_3 $PINS A=n366 X=n367
XU753 SEN_ND2_1P5 $PINS A1=n780 A2=n620 X=n786
XU754 SEN_ND2_S_4 $PINS A1=n782 A2=n622 X=n624
XU755 SEN_AOAI211_3 $PINS A1=n525 A2=n850 B=n849 C=n848 X=n851
XU756 SEN_ND3_T_1 $PINS A1=net15897 A2=net16015 A3=net16014 X=net15934
XU757 SEN_OAI21_S_3 $PINS A1=net16013 A2=n804 B=net17656 X=n777
XU758 SEN_INV_S_6 $PINS A=net3736 X=n409
XU759 SEN_OAI211_8 $PINS A1=net16102 A2=n443 B1=net16103 B2=net16104 X=net3736
XU760 SEN_EO2_G_8 $PINS A1=n535 A2=n727 X=net16102
XU761 SEN_ND2_T_1 $PINS A1=net16497 A2=A[31] X=net17572
XU762 SEN_NR2_G_1 $PINS A1=net16497 A2=net16495 X=n391
XU763 SEN_BUF_8 $PINS A=INST[2] X=net16497
XU764 SEN_ND2_2 $PINS A1=net16288 A2=net16289 X=net15971
XU765 SEN_INV_2 $PINS A=n441 X=net16085
XU766 SEN_AO21B_6 $PINS A1=net15971 A2=net15946 B=net15942 X=n399
XU767 SEN_AN2_3 $PINS A1=net15971 A2=n799 X=n531
XU768 SEN_INV_S_4 $PINS A=Z[19] X=n416
XU769 SEN_INV_S_4 $PINS A=Z[18] X=n422
XU770 SEN_ND2_2 $PINS A1=net15980 A2=net15979 X=n505
XU771 SEN_INV_S_2 $PINS A=net16288 X=net15980
XU772 SEN_INV_S_4 $PINS A=net15910 X=net16062
XU773 SEN_ND2_T_3 $PINS A1=n751 A2=n527 X=net15910
XU774 SEN_BUF_S_6 $PINS A=net16299 X=net17648
XU775 SEN_ND2_S_1 $PINS A1=n778 A2=n777 X=n468
XU776 SEN_INV_S_2 $PINS A=net16180 X=net17600
XU777 SEN_MUXI2_DG_3 $PINS D0=n551 D1=n511 S=B[0] X=n618
XU778 SEN_OAI211_3 $PINS A1=net15975 A2=net16412 B1=net15976 B2=net15977
+ X=net3742
XU779 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n494 S=B[25] X=n682
XU780 SEN_OAI21B_2 $PINS A1=net15865 A2=n832 B=n831 X=n833
XU781 SEN_ND2_T_4 $PINS A1=net15794 A2=net15795 X=net16215
XU782 SEN_ND2_G_1 $PINS A1=net16223 A2=net16222 X=net15795
XU783 SEN_NR3B_DG_8 $PINS A=n813 B1=n644 B2=n643 X=n645
XU784 SEN_ND2_S_1P5 $PINS A1=net16014 A2=net17656 X=n402
XU785 SEN_EN2_8 $PINS A1=n358 A2=n836 X=n758
XU786 SEN_MUXI2_S_1 $PINS D0=n550 D1=n494 S=B[15] X=n594
XU787 SEN_ND4_S_3 $PINS A1=net16344 A2=net16345 A3=net16077 A4=n364 X=net15798
XU788 SEN_ND2_S_1 $PINS A1=net17656 A2=net15897 X=net16023
XU789 SEN_OAI21_5 $PINS A1=n659 A2=n658 B=n657 X=net15914
XU790 SEN_INV_2 $PINS A=net16153 X=n442
XU791 SEN_EN2_8 $PINS A1=n806 A2=n807 X=n804
XU792 SEN_ND2_S_6 $PINS A1=net16361 A2=net16360 X=net17414
XU793 SEN_ND2_T_1P5 $PINS A1=n554 A2=n608 X=net16327
XU794 SEN_MUXI2_S_2 $PINS D0=n551 D1=n493 S=B[8] X=n608
XU795 SEN_OAI211_3 $PINS A1=net15963 A2=net16412 B1=net15964 B2=net15965
+ X=net3727
XU796 SEN_ND2_T_2 $PINS A1=n518 A2=B[16] X=n509
XU797 SEN_ND2B_V1_4 $PINS A=net15915 B=net15916 X=net15912
XU798 SEN_NR2B_V1_2 $PINS A=net17656 B=n820 X=n526
XU799 SEN_ND2_T_2 $PINS A1=n544 A2=n632 X=n753
XU800 SEN_ND2_T_4 $PINS A1=n630 A2=n554 X=n544
XU801 SEN_ND2_2 $PINS A1=net16476 A2=n595 X=n638
XU802 SEN_MUXI2_DG_2 $PINS D0=net16482 D1=n683 S=A[10] X=n642
XU803 SEN_INV_2 $PINS A=net16407 X=net16309
XU804 SEN_ND2_T_1 $PINS A1=n651 A2=n650 X=n760
XU805 SEN_NR2_T_4 $PINS A1=net16691 A2=n451 X=n490
XU806 SEN_EN2_S_3 $PINS A1=n856 A2=n851 X=net15830
XU807 SEN_INV_S_4 $PINS A=Z[20] X=n415
XU808 SEN_OAI211_4 $PINS A1=net15817 A2=net16410 B1=net15818 B2=net15819
+ X=Z[20]
XU809 SEN_ND2_T_1 $PINS A1=net17602 A2=n642 X=n646
XU810 SEN_ND2_S_0P5 $PINS A1=n686 A2=n685 X=net16190
XU811 SEN_INV_2 $PINS A=n685 X=n713
XU812 SEN_ND2_G_1 $PINS A1=net17602 A2=n684 X=n685
XU813 SEN_OAI21_T_4 $PINS A1=net16410 A2=net16155 B=net16156 X=net3724
XU814 SEN_EN2_S_6 $PINS A1=n710 A2=n706 X=net16155
XU815 SEN_OR3B_4 $PINS B1=Z[21] B2=Z[23] A=n381 X=n388
XU816 SEN_ND2_T_2 $PINS A1=n636 A2=net17602 X=n650
XU817 SEN_INV_S_2 $PINS A=n484 X=n636
XU818 SEN_MUXI2_DG_0P75 $PINS D0=n550 D1=n367 S=B[27] X=n562
XU819 SEN_EO2_3 $PINS A1=net15969 A2=n531 X=net15963
XU820 SEN_AOI21B_4 $PINS A1=n654 A2=n653 B=n652 X=n659
XU821 SEN_EO2_1 $PINS A1=net15791 A2=net15790 X=net17005
XU822 SEN_OAI21_2 $PINS A1=n734 A2=n733 B=n732 X=n735
XU823 SEN_INV_3 $PINS A=n733 X=n737
XU824 SEN_EO2_3 $PINS A1=n723 A2=n725 X=n733
XU825 SEN_ND2_S_4 $PINS A1=n553 A2=n602 X=net16336
XU826 SEN_EN2_5 $PINS A1=n789 A2=n788 X=n785
XU827 SEN_INV_2 $PINS A=n748 X=n465
XU828 SEN_INV_6 $PINS A=Z[15] X=n426
XU829 SEN_OAI211_8 $PINS A1=net15902 A2=net16410 B1=net15903 B2=net15904
+ X=Z[15]
XU830 SEN_AOI21_6 $PINS A1=n672 A2=n866 B=n452 X=n675
XU831 SEN_INV_S_4 $PINS A=n660 X=n810
XU832 SEN_INV_0P65 $PINS A=net16127 X=net16123
XU833 SEN_INV_1 $PINS A=net15934 X=net16013
XU834 SEN_MUXI2_DG_3 $PINS D0=n551 D1=n517 S=B[17] X=n592
XU835 SEN_ND2_T_2 $PINS A1=net16476 A2=n603 X=net16337
XU836 SEN_OR4B_4 $PINS B1=n694 B2=n693 B3=n692 A=n691 X=n706
XU837 SEN_ND2_8 $PINS A1=net15916 A2=net17750 X=net18157
XU838 SEN_NR2_8 $PINS A1=n513 A2=n491 X=n512
XU839 SEN_EN2_S_2 $PINS A1=n527 A2=n827 X=net15869
XU840 SEN_OAI211_3 $PINS A1=net15869 A2=net16410 B1=net15870 B2=net15871
+ X=Z[10]
XU841 SEN_NR2_T_2 $PINS A1=net3721 A2=Z[10] X=n425
XU842 SEN_INV_S_6 $PINS A=n658 X=n814
XU843 SEN_EN2_5 $PINS A1=n762 A2=n763 X=n658
XU844 SEN_INV_1 $PINS A=n770 X=n821
XU845 SEN_BUF_8 $PINS A=INST[0] X=net16501
XU846 SEN_EN2_3 $PINS A1=net16999 A2=n711 X=net16144
XU847 SEN_OA21_2 $PINS A1=n442 A2=net16084 B=net16999 X=net17035
XU848 SEN_EO2_G_2 $PINS A1=n712 A2=n713 X=net16999
XU849 SEN_ND2_T_4 $PINS A1=n627 A2=n554 X=net16288
XU850 SEN_OR3B_4 $PINS B1=n721 B2=n731 A=n720 X=n722
XU851 SEN_ND2_6 $PINS A1=net15916 A2=net17750 X=n398
XU852 SEN_EN2_S_1 $PINS A1=n702 A2=FLAGS[1] X=FLAGS[0]
XU853 SEN_AO2BB2_2 $PINS A1=n702 A2=n705 B1=n701 B2=n709 X=FLAGS[1]
XU854 SEN_EO2_2 $PINS A1=n821 A2=n773 X=n776
XU855 SEN_ND2_S_4 $PINS A1=n459 A2=n460 X=net15902
XU856 SEN_ND3_T_4 $PINS A1=n400 A2=net16215 A3=net17005 X=net16127
XU857 SEN_ND4B_4 $PINS A=net15798 B1=n398 B2=net15795 B3=net15796 X=n400
XU858 SEN_OAOI211_2 $PINS A1=net16023 A2=n820 B=n521 C=net15882 X=n773
XU859 SEN_ND2_4 $PINS A1=n765 A2=n492 X=n813
XU860 SEN_ND2_4 $PINS A1=n450 A2=net17829 X=n457
XU861 SEN_INV_1 $PINS A=net15883 X=net17829
XU862 SEN_INV_S_1 $PINS A=n576 X=n723
XU863 SEN_INV_S_1 $PINS A=n715 X=n470
XU864 SEN_EO2_2 $PINS A1=net15889 A2=net15888 X=n523
XU865 SEN_INV_S_1 $PINS A=net16165 X=net16410
XU866 SEN_ND2_2 $PINS A1=n683 A2=A[13] X=n483
XU867 SEN_INV_2 $PINS A=n559 X=n698
XU868 SEN_ND2_S_3 $PINS A1=n785 A2=n791 X=n797
XU869 SEN_INV_3 $PINS A=net17600 X=net17602
XU870 SEN_BUF_6 $PINS A=INST[3] X=net16495
XU871 SEN_INV_S_4 $PINS A=net16301 X=net15967
XU872 SEN_INV_2 $PINS A=n488 X=n489
XU873 SEN_INV_1 $PINS A=net16326 X=net15889
XU874 SEN_EN2_0P5 $PINS A1=n810 A2=n811 X=n378
XU875 SEN_INV_S_2 $PINS A=n879 X=n462
XU876 SEN_INV_S_1 $PINS A=net16193 X=n439
XU877 SEN_EO2_S_0P5 $PINS A1=n739 A2=n741 X=n579
XU878 SEN_INV_S_1 $PINS A=net16424 X=net16772
XU879 SEN_ND2_G_1 $PINS A1=net18219 A2=n821 X=n775
XU880 SEN_EO2_G_2 $PINS A1=net16070 A2=net16069 X=net17000
XU881 SEN_ND2_G_1 $PINS A1=net16196 A2=net16197 X=net16134
XU882 SEN_EN2_1 $PINS A1=n439 A2=net16134 X=net16938
XU883 SEN_INV_2 $PINS A=net16165 X=net16412
XU884 SEN_EN2_1 $PINS A1=n730 A2=n728 X=n535
XU885 SEN_ND2_S_3 $PINS A1=n407 A2=n408 X=n406
XU886 SEN_ND2_G_1 $PINS A1=net16669 A2=A[12] X=n473
XU887 SEN_INV_S_1 $PINS A=B[13] X=n541
XU888 SEN_ND2_G_1 $PINS A1=n482 A2=n483 X=n484
XU889 SEN_MUXI2_S_1 $PINS D0=net16480 D1=n683 S=A[15] X=n595
XU890 SEN_INV_6 $PINS A=net16478 X=net16476
XU891 SEN_ND2_G_1 $PINS A1=n553 A2=n582 X=n670
XU892 SEN_ND2_G_1 $PINS A1=net17602 A2=n586 X=n674
XU893 SEN_INV_1 $PINS A=net16074 X=net16220
XU894 SEN_ND2_G_1 $PINS A1=net17602 A2=n679 X=n681
XU895 SEN_ND2_G_1 $PINS A1=n555 A2=n678 X=n680
XU896 SEN_MUXI2_S_0P5 $PINS D0=net16482 D1=n549 S=A[25] X=n684
XU897 SEN_OAI21_S_2 $PINS A1=net17035 A2=net16143 B=net16938 X=net16188
XU898 SEN_INV_S_3 $PINS A=net16289 X=net15979
XU899 SEN_INV_S_1 $PINS A=B[3] X=n546
XU900 SEN_INV_3 $PINS A=net15769 X=net16691
XU901 SEN_INV_1 $PINS A=n671 X=n861
XU902 SEN_ND2_2 $PINS A1=n668 A2=n669 X=n866
XU903 SEN_INV_S_1 $PINS A=n686 X=n712
XU904 SEN_INV_S_1 $PINS A=n575 X=n728
XU905 SEN_ND2_S_1 $PINS A1=n535 A2=n537 X=n718
XU906 SEN_INV_3 $PINS A=net16501 X=net16182
XU907 SEN_INV_3 $PINS A=net17601 X=net16478
XU908 SEN_INV_2 $PINS A=net17600 X=net17601
XU909 SEN_AOI21B_1 $PINS A1=n793 A2=n792 B=n791 X=n794
XU910 SEN_ND2_T_1 $PINS A1=n771 A2=n467 X=n469
XU911 SEN_INV_S_1 $PINS A=n662 X=n880
XU912 SEN_ND2_G_1 $PINS A1=n539 A2=n879 X=n463
XU913 SEN_ND2_G_1 $PINS A1=n461 A2=n462 X=n464
XU914 SEN_ND2_T_1 $PINS A1=n364 A2=net18157 X=n840
XU915 SEN_EN2_DG_1 $PINS A1=n886 A2=n889 X=n537
XU916 SEN_OAI211_1 $PINS A1=net15986 A2=net16412 B1=net15987 B2=net15988 X=Z[1]
XU917 SEN_EN2_1 $PINS A1=n793 A2=n792 X=net15986
XU918 SEN_OAOI211_G_1 $PINS A1=B[8] A2=A[8] B=net16444 C=n774 X=net16018
XU919 SEN_OA21_2 $PINS A1=n776 A2=net16412 B=n775 X=net17804
XU920 SEN_OAI211_3 $PINS A1=net16078 A2=net16412 B1=net16079 B2=net16080
+ X=net3748
XU921 SEN_ND2_2 $PINS A1=n453 A2=n454 X=net16078
XU922 SEN_OAI211_3 $PINS A1=n434 A2=n443 B1=n435 B2=n436 X=net3754
XU923 SEN_ND2B_6 $PINS A=net16495 B=n393 X=n395
XU924 SEN_INV_S_2 $PINS A=Z[13] X=n424
XU925 SEN_ND3_S_0P5 $PINS A1=n814 A2=n813 A3=n834 X=n815
XU926 SEN_AOAI211_8 $PINS A1=n389 A2=net16497 B=net16501 C=n390 X=net16177
XU927 SEN_ND2_12 $PINS A1=net17349 A2=net17579 X=net16669
XU928 SEN_OAOI211_G_1 $PINS A1=B[2] A2=A[2] B=net16444 C=n795 X=net15977
XU929 SEN_INV_S_1 $PINS A=n704 X=n558
XU930 SEN_ND2_G_4 $PINS A1=n486 A2=n487 X=net16985
XU931 SEN_INV_S_3 $PINS A=net3748 X=n418
XU932 SEN_ND2_S_2 $PINS A1=n440 A2=n446 X=n449
XU933 SEN_ND2_2 $PINS A1=n448 A2=n449 X=n434
XU934 SEN_ND2_S_0P5 $PINS A1=n704 A2=n542 X=net16165
XU935 SEN_ND2_S_3 $PINS A1=n767 A2=n768 X=n515
XU936 SEN_EO2_G_4 $PINS A1=n766 A2=n530 X=net16028
XU937 SEN_INV_S_1 $PINS A=net16691 X=net16774
XU938 SEN_ND2B_V1_3 $PINS A=net16478 B=n631 X=n632
XU939 SEN_INV_S_3 $PINS A=n552 X=n550
XU940 SEN_INV_S_8 $PINS A=n552 X=n551
XU941 SEN_AN2_S_1 $PINS A1=n543 A2=n365 X=n371
XU942 SEN_INV_S_1 $PINS A=n556 X=n555
XU943 SEN_OR2_1 $PINS A1=A[31] A2=B[31] X=n372
XU944 SEN_OR2_1 $PINS A1=A[29] A2=B[29] X=n373
XU945 SEN_OR2_1 $PINS A1=A[30] A2=B[30] X=n374
XU946 SEN_INV_S_1 $PINS A=n359 X=net16448
XU947 SEN_NR2_0P8 $PINS A1=n399 A2=net15960 X=net15958
XU948 SEN_MUXI2_S_1 $PINS D0=net16480 D1=n549 S=A[20] X=n584
XU949 SEN_NR3_T_0P5 $PINS A1=n861 A2=n860 A3=net16774 X=n862
XU950 SEN_ND2B_S_4 $PINS A=net16179 B=net16400 X=n700
XU951 SEN_MUXI2_DG_1 $PINS D0=n551 D1=n494 S=B[10] X=n641
XU952 SEN_ND2_T_6 $PINS A1=net16361 A2=net16179 X=n392
XU953 SEN_ND2B_V1_1 $PINS A=A[31] B=net16497 X=n695
XU954 SEN_INV_0P65 $PINS A=net15894 X=net15883
XU955 SEN_MUXI2_DG_1 $PINS D0=net16482 D1=net16669 S=A[5] X=n613
XU956 SEN_INV_4 $PINS A=net16499 X=n393
XU957 SEN_INV_8 $PINS A=net17655 X=net17656
XU958 SEN_INV_0P8 $PINS A=n440 X=n447
XU959 SEN_EN2_S_3 $PINS A1=n859 A2=n858 X=net15817
XU960 SEN_INV_1 $PINS A=n669 X=n853
XU961 SEN_INV_S_8 $PINS A=net17749 X=net17750
XU962 SEN_INV_S_3 $PINS A=n503 X=n627
XU963 SEN_INV_4 $PINS A=net16495 X=net16400
XU964 SEN_ND2_T_1P5 $PINS A1=n478 A2=n479 X=n480
XU965 SEN_ND2_G_1 $PINS A1=n550 A2=n540 X=n479
XU966 SEN_NR3_0P8 $PINS A1=net15940 A2=net16723 A3=net16422 X=net15939
XU967 SEN_ND2_2 $PINS A1=n796 A2=net15961 X=net17427
XU968 SEN_INV_4 $PINS A=net17427 X=net17428
XU969 SEN_ND3_S_8 $PINS A1=n814 A2=n834 A3=net16985 X=n644
XU970 SEN_INV_2 $PINS A=n656 X=n762
XU971 SEN_NR3B_3 $PINS A=net15796 B1=net15797 B2=net15798 X=n875
XU972 SEN_MUXI2_S_3 $PINS D0=n683 D1=net16482 S=n545 X=n626
XU973 SEN_ND2_0P5 $PINS A1=net18219 A2=n524 X=net15996
XU974 SEN_INV_S_1 $PINS A=n865 X=n859
XU975 SEN_AO21_4 $PINS A1=n845 A2=n866 B=n865 X=n452
XU976 SEN_ND2_S_0P5 $PINS A1=n866 A2=n848 X=n863
XU977 SEN_ND2_1P5 $PINS A1=n664 A2=n665 X=n848
XU978 SEN_INV_0P5 $PINS A=n780 X=n783
XU979 SEN_INV_S_4 $PINS A=n749 X=n475
XU980 SEN_INV_4 $PINS A=net17189 X=net17190
XU981 SEN_ND2_T_2 $PINS A1=n607 A2=n606 X=net15899
XU982 SEN_AN2_6 $PINS A1=net16400 A2=net16182 X=net16968
XU983 SEN_NR2B_2 $PINS A=net18157 B=net15829 X=n857
XU984 SEN_INV_S_0P5 $PINS A=net16300 X=net15968
XU985 SEN_ND2_6 $PINS A1=n394 A2=n395 X=n389
XU986 SEN_INV_2 $PINS A=n655 X=n763
XU987 SEN_ND2_2 $PINS A1=net16400 A2=net16182 X=n379
XU988 SEN_BUF_1 $PINS A=net16361 X=n382
XU989 SEN_MUXI2_S_1 $PINS D0=net16480 D1=n549 S=A[24] X=n679
XU990 SEN_ND2_T_2 $PINS A1=n842 A2=n665 X=n384
XU991 SEN_INV_S_3 $PINS A=n842 X=n383
XU992 SEN_NR3B_3 $PINS A=net18157 B1=n864 B2=n863 X=n870
XU993 SEN_OAI31_1 $PINS A1=net16495 A2=net16309 A3=net16182 B=n621 X=n622
XU994 SEN_ND2_6 $PINS A1=n645 A2=n751 X=net17749
XU995 SEN_MUXI2_DG_1 $PINS D0=n550 D1=n368 S=B[19] X=n587
XU996 SEN_INV_1 $PINS A=n866 X=n589
XU997 SEN_INV_0P8 $PINS A=net16499 X=net17564
XU998 SEN_ND2_4 $PINS A1=n515 A2=n516 X=n765
XU999 SEN_ND2_G_1 $PINS A1=n848 A2=n543 X=net15829
XU1000 SEN_AO222_1 $PINS A1=net18219 A2=n737 B1=n359 B2=n373 C1=n725 C2=n724
+ X=n386
XU1001 SEN_BUF_1 $PINS A=n532 X=n387
XU1002 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n387 X=net15847
XU1003 SEN_OAI21_S_0P5 $PINS A1=n520 A2=n362 B=n387 X=n849
XU1004 SEN_INV_S_3 $PINS A=net3751 X=n408
XU1005 SEN_NR3_0P5 $PINS A1=n807 A2=n806 A3=net16772 X=n808
XU1006 SEN_INV_8 $PINS A=n392 X=net17349
XU1007 SEN_OR2_2 $PINS A1=n885 A2=n537 X=n548
XU1008 SEN_INV_1 $PINS A=n816 X=n458
XU1009 SEN_ND2_S_4 $PINS A1=n466 A2=net16074 X=n749
XU1010 SEN_INV_1P5 $PINS A=n391 X=n390
XU1011 SEN_INV_S_0P5 $PINS A=n382 X=net18246
XU1012 SEN_ND2_S_0P5 $PINS A1=net16361 A2=net17579 X=net16201
XU1013 SEN_ND2B_V1DG_2 $PINS A=A[31] B=net16968 X=net17579
XU1014 SEN_ND2_6 $PINS A1=net17190 A2=net17428 X=net16015
XU1015 SEN_OAI221_4 $PINS A1=net16949 A2=net15961 B1=n403 B2=net16949
+ C=net15953 X=net15897
XU1016 SEN_OR2_2 $PINS A1=n401 A2=n402 X=net17773
XU1017 SEN_ND2_2 $PINS A1=net16326 A2=net16325 X=net15880
XU1018 SEN_ND2_G_1 $PINS A1=net16328 A2=net16327 X=net15894
XU1019 SEN_INV_4 $PINS A=n399 X=n403
XU1020 SEN_ND2_3 $PINS A1=net16300 A2=net16301 X=net15946
XU1021 SEN_NR2B_V1DG_1 $PINS A=net15942 B=net15960 X=net15956
XU1022 SEN_BUF_1 $PINS A=net15942 X=net16701
XU1023 SEN_NR4_3 $PINS A1=n404 A2=n405 A3=n406 A4=net3724 X=FLAGS[2]
XU1024 SEN_ND3_S_4 $PINS A1=n411 A2=n412 A3=n413 X=n404
XU1025 SEN_AN3B_4 $PINS B1=n417 B2=n418 A=n419 X=n411
XU1026 SEN_NR2_S_4 $PINS A1=n427 A2=Z[11] X=n444
XU1027 SEN_ND3_S_4 $PINS A1=n428 A2=n429 A3=n430 X=n427
XU1028 SEN_OAI211_3 $PINS A1=net16005 A2=net16412 B1=net16006 B2=net16007
+ X=net3715
XU1029 SEN_NR4_6 $PINS A1=net3730 A2=net3712 A3=n431 A4=net3733 X=n429
XU1030 SEN_OAI211_3 $PINS A1=net15936 A2=net16412 B1=net15937 B2=net15938
+ X=net3730
XU1031 SEN_ND2_S_3 $PINS A1=n432 A2=n433 X=n431
XU1032 SEN_INV_2 $PINS A=net3727 X=n432
XU1033 SEN_OAI211_8 $PINS A1=net15947 A2=net16412 B1=net15948 B2=net15949
+ X=net3733
XU1034 SEN_OAI211_4 $PINS A1=net16037 A2=net16412 B1=net16038 B2=net16039
+ X=Z[14]
XU1035 SEN_NR2_S_4 $PINS A1=n423 A2=Z[16] X=n421
XU1036 SEN_ND3_S_4 $PINS A1=n424 A2=n426 A3=n425 X=n423
XU1037 SEN_OAI211_2 $PINS A1=net15857 A2=net16410 B1=net15858 B2=net15859
+ X=Z[13]
XU1038 SEN_OAI211_1 $PINS A1=net15919 A2=net16410 B1=net15920 B2=net15921
+ X=Z[16]
XU1039 SEN_OAI211_3 $PINS A1=net15846 A2=net16410 B1=net15847 B2=net15848
+ X=Z[18]
XU1040 SEN_ND2_T_6 $PINS A1=net17713 A2=net15775 X=Z[17]
XU1041 SEN_ND2_2 $PINS A1=n447 A2=net16938 X=n448
XU1042 SEN_INV_S_0P5 $PINS A=net16938 X=n446
XU1043 SEN_INV_S_0P5 $PINS A=net16165 X=n443
XU1044 SEN_ND2_S_0P5 $PINS A1=net18219 A2=net16938 X=n435
XU1045 SEN_OA2BB2_0P5 $PINS A1=net16134 A2=n437 B1=n438 B2=net16448 X=n436
XU1046 SEN_NR2_S_0P5 $PINS A1=n439 A2=net16774 X=n437
XU1047 SEN_NR2_1 $PINS A1=A[26] A2=B[26] X=n438
XU1048 SEN_INV_S_0P5 $PINS A=net16190 X=net16143
XU1049 SEN_AO21B_6 $PINS A1=net16073 A2=net16074 B=net17000 X=net15794
XU1050 SEN_NR2_T_2 $PINS A1=net16127 A2=net16188 X=net17788
XU1051 SEN_ND2_6 $PINS A1=net16057 A2=n813 X=n832
XU1052 SEN_AN2_3 $PINS A1=net18157 A2=n846 X=n519
XU1053 SEN_INV_S_2 $PINS A=n777 X=n467
XU1054 SEN_NR3_T_3 $PINS A1=n747 A2=net16220 A3=n589 X=net16344
XU1055 SEN_INV_2 $PINS A=n868 X=n747
XU1056 SEN_ND2_0P8 $PINS A1=n551 A2=n507 X=n508
XU1057 SEN_INV_S_4 $PINS A=net15899 X=net17655
XU1058 SEN_ND2B_4 $PINS A=net16497 B=net16495 X=n557
XU1059 SEN_INV_S_6 $PINS A=net18157 X=net15797
XU1060 SEN_ND2_2 $PINS A1=n465 A2=net17799 X=n466
XU1061 SEN_INV_S_2 $PINS A=n646 X=n829
XU1062 SEN_EO2_2 $PINS A1=n387 A2=n841 X=net15846
XU1063 SEN_OAOI211_3 $PINS A1=n840 A2=n839 B=n520 C=n362 X=n841
XU1064 SEN_ND2_2 $PINS A1=n544 A2=n632 X=n516
XU1065 SEN_INV_2 $PINS A=n818 X=n485
XU1066 SEN_ND2_S_2 $PINS A1=n637 A2=n818 X=n487
XU1067 SEN_NR3_0P5 $PINS A1=net16774 A2=n818 A3=n817 X=n819
XU1068 SEN_ND3_T_0P8 $PINS A1=net16495 A2=net16497 A3=net16501 X=n583
XU1069 SEN_ND2_S_1P5 $PINS A1=net17602 A2=n634 X=n655
XU1070 SEN_NR2_T_3 $PINS A1=net17564 A2=n379 X=n497
XU1071 SEN_AN2_3 $PINS A1=n365 A2=n846 X=n525
XU1072 SEN_INV_1 $PINS A=n845 X=n856
XU1073 SEN_MUXI2_S_1 $PINS D0=n550 D1=n517 S=B[20] X=n582
XU1074 SEN_ND2B_V1_1 $PINS A=n583 B=net16499 X=net16180
XU1075 SEN_MUXI2_S_2 $PINS D0=net16480 D1=n683 S=A[18] X=n591
XU1076 SEN_EN2_DG_4 $PINS A1=n805 A2=net15934 X=net15927
XU1077 SEN_AOI21B_4 $PINS A1=n885 A2=n537 B=n726 X=n727
XU1078 SEN_ND2_1P5 $PINS A1=net16476 A2=n588 X=n669
XU1079 SEN_NR3_T_0P5 $PINS A1=net15967 A2=net15968 A3=net15769 X=n798
XU1080 SEN_ND2_T_1P5 $PINS A1=net16476 A2=n601 X=net16325
XU1081 SEN_INV_2 $PINS A=net16325 X=net15888
XU1082 SEN_MUXI2_S_2 $PINS D0=net16480 D1=n683 S=A[9] X=n601
XU1083 SEN_MUX2_1 $PINS D0=n512 D1=n552 S=n546 X=n625
XU1084 SEN_INV_S_1 $PINS A=net16440 X=net18219
XU1085 SEN_OR2_DG_1 $PINS A1=n560 A2=n363 X=net16440
XU1086 SEN_MUXI2_S_3 $PINS D0=n551 D1=n494 S=B[1] X=n614
XU1087 SEN_MUXI2_S_1 $PINS D0=n550 D1=n494 S=B[9] X=n600
XU1088 SEN_OAI21_S_0P5 $PINS A1=n534 A2=n832 B=n759 X=n831
XU1089 SEN_MUXI2_DG_3 $PINS D0=n551 D1=n517 S=B[11] X=n630
XU1090 SEN_INV_1 $PINS A=net15969 X=net18184
XU1091 SEN_INV_S_0P5 $PINS A=n804 X=n805
XU1092 SEN_EO2_G_4 $PINS A1=net15953 A2=n801 X=net15947
XU1093 SEN_INV_S_0P5 $PINS A=net15945 X=net15969
XU1094 SEN_OAOI211_G_1 $PINS A1=B[3] A2=A[3] B=net16444 C=n798 X=net15965
XU1095 SEN_EN2_S_2 $PINS A1=net16701 A2=n803 X=net15936
XU1096 SEN_INV_S_0P5 $PINS A=net16073 X=net17799
XU1097 SEN_MUXI2_S_1 $PINS D0=n551 D1=n518 S=B[14] X=n633
XU1098 SEN_ND2_T_1 $PINS A1=n553 A2=n600 X=net16326
XU1099 SEN_EO2_S_3 $PINS A1=n872 A2=n873 X=n522
XU1100 SEN_MUXI2_S_2 $PINS D0=net16480 D1=n549 S=A[19] X=n588
XU1101 SEN_ND2_3 $PINS A1=net16476 A2=n640 X=n648
XU1102 SEN_ND3B_V1DG_1 $PINS A=net16499 B1=net16501 B2=net16497 X=n563
XU1103 SEN_INV_1 $PINS A=net17572 X=net17573
XU1104 SEN_NR3_T_0P5 $PINS A1=net16009 A2=net16010 A3=net16772 X=n779
XU1105 SEN_ND2B_V1DG_2 $PINS A=A[31] B=net16968 X=net16360
XU1106 SEN_INV_2 $PINS A=n648 X=n756
XU1107 SEN_ND2_S_3 $PINS A1=net16476 A2=n613 X=net16298
XU1108 SEN_MUXI2_S_4 $PINS D0=net16482 D1=n683 S=A[0] X=n619
XU1109 SEN_INV_S_0P5 $PINS A=n765 X=n766
XU1110 SEN_BUF_S_4 $PINS A=n753 X=n492
XU1111 SEN_ND2_2 $PINS A1=net16476 A2=n591 X=n665
XU1112 SEN_EO2_G_4 $PINS A1=n828 A2=n829 X=n527
XU1113 SEN_EO2_G_2 $PINS A1=n814 A2=n761 X=net16037
XU1114 SEN_INV_S_2 $PINS A=n616 X=n789
XU1115 SEN_AN2_2 $PINS A1=n752 A2=net15865 X=n530
XU1116 SEN_INV_0P65 $PINS A=n706 X=n702
XU1117 SEN_MUXI2_S_3 $PINS D0=net16482 D1=net16669 S=A[6] X=n605
XU1118 SEN_ND2_2 $PINS A1=n637 A2=n638 X=net16077
XU1119 SEN_ND2_T_3 $PINS A1=n817 A2=n485 X=n486
XU1120 SEN_NR3_0P5 $PINS A1=net16499 A2=n695 A3=net16182 X=n697
XU1121 SEN_INV_2 $PINS A=net16327 X=net16021
XU1122 SEN_NR4B_4 $PINS A=net18157 B1=n864 B2=n747 B3=n863 X=n748
XU1123 SEN_BUF_3 $PINS A=n746 X=n543
XU1124 SEN_ND2_2 $PINS A1=n880 A2=n663 X=n455
XU1125 SEN_ND2_2 $PINS A1=n458 A2=net17816 X=n460
XU1126 SEN_INV_S_0P5 $PINS A=net16985 X=net17816
XU1127 SEN_OAI31_3 $PINS A1=net15910 A2=n815 A3=net15912 B=net15913 X=n816
XU1128 SEN_INV_S_1 $PINS A=n539 X=n461
XU1129 SEN_ND2_2 $PINS A1=n468 A2=n469 X=net16005
XU1130 SEN_INV_S_1 $PINS A=A[12] X=n471
XU1131 SEN_INV_S_3 $PINS A=n474 X=n640
XU1132 SEN_ND2_S_4 $PINS A1=net17760 A2=n475 X=n477
XU1133 SEN_INV_S_1 $PINS A=net17000 X=net17760
XU1134 SEN_INV_2 $PINS A=n480 X=n590
XU1135 SEN_ND2_G_1 $PINS A1=net16482 A2=n481 X=n482
XU1136 SEN_INV_1 $PINS A=A[13] X=n481
XU1137 SEN_ND2_S_0P5 $PINS A1=net16434 A2=net16985 X=net15904
XU1138 SEN_OAOI211_8 $PINS A1=B[17] A2=A[17] B=net16444 C=n882 X=net15775
XU1139 SEN_AOAI211_3 $PINS A1=n525 A2=n857 B=n867 C=n866 X=n858
XU1140 SEN_ND2_G_1 $PINS A1=net16434 A2=n834 X=net15858
XU1141 SEN_INV_S_0P5 $PINS A=n378 X=n809
XU1142 SEN_INV_0P8 $PINS A=net16478 X=net16474
XU1143 SEN_INV_S_0P5 $PINS A=net16448 X=net17584
XU1144 SEN_OAOI211_2 $PINS A1=B[5] A2=A[5] B=net16444 C=n802 X=net15949
XU1145 SEN_OAOI211_2 $PINS A1=B[6] A2=A[6] B=net16444 C=n808 X=net15929
XU1146 SEN_OAOI211_1 $PINS A1=B[4] A2=A[4] B=net16444 C=net15939 X=net15938
XU1147 SEN_INV_S_0P5 $PINS A=n492 X=n496
XU1148 SEN_ND2_G_1 $PINS A1=n551 A2=n500 X=n501
XU1149 SEN_INV_1 $PINS A=B[2] X=n500
XU1150 SEN_INV_1 $PINS A=net16188 X=net16125
XU1151 SEN_INV_1 $PINS A=n674 X=n873
XU1152 SEN_INV_0P8 $PINS A=n681 X=n744
XU1153 SEN_INV_S_1 $PINS A=B[16] X=n507
XU1154 SEN_OAOI211_1 $PINS A1=B[25] A2=A[25] B=n359 C=n714 X=net16146
XU1155 SEN_NR2_S_0P5 $PINS A1=n718 A2=n581 X=n690
XU1156 SEN_ND2B_1 $PINS A=n726 B=n535 X=n716
XU1157 SEN_OAOI211_1 $PINS A1=B[22] A2=A[22] B=net17584 C=n750 X=net16065
XU1158 SEN_NR3_0P5 $PINS A1=n843 A2=n842 A3=net16774 X=n844
XU1159 SEN_NR3_0P5 $PINS A1=n829 A2=n828 A3=net16772 X=n830
XU1160 SEN_MUXI2_S_0P5 $PINS D0=net16482 D1=net16669 S=A[14] X=n634
XU1161 SEN_NR3_T_0P5 $PINS A1=net15888 A2=net15889 A3=net16772 X=n825
XU1162 SEN_INV_1 $PINS A=n705 X=n710
XU1163 SEN_ND2_S_0P5 $PINS A1=n656 A2=n655 X=n657
XU1164 SEN_ND2_S_0P5 $PINS A1=n580 A2=n889 X=n726
XU1165 SEN_ND2_S_0P5 $PINS A1=n555 A2=n699 X=n701
XU1166 SEN_OAOI211_0P5 $PINS A1=B[13] A2=A[13] B=net16444 C=n837 X=net15859
XU1167 SEN_OAOI211_1 $PINS A1=B[14] A2=A[14] B=net16444 C=n764 X=net16039
XU1168 SEN_INV_1 $PINS A=net16448 X=net16444
XU1169 SEN_ND2_G_1 $PINS A1=n737 A2=n742 X=n581
XU1170 SEN_NR3_0P5 $PINS A1=n881 A2=n880 A3=net16774 X=n882
XU1171 SEN_NR3_0P5 $PINS A1=n744 A2=n743 A3=net16772 X=n745
XU1172 SEN_ND3_S_0P5 $PINS A1=net16153 A2=net16154 A3=net16190 X=n719
XU1173 SEN_AOI222_1 $PINS A1=net16434 A2=n710 B1=net17584 B2=n372 C1=n709
+ C2=n708 X=net16156
XU1174 SEN_INV_S_1 $PINS A=net16191 X=net15791
XU1175 SEN_OAOI211_1 $PINS A1=B[21] A2=A[21] B=net17584 C=n874 X=net15800
XU1176 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n522 X=net15801
XU1177 SEN_OAOI211_1 $PINS A1=B[19] A2=A[19] B=net17584 C=n854 X=net15832
XU1178 SEN_ND2_G_1 $PINS A1=n574 A2=n573 X=n741
XU1179 SEN_OAOI211_1 $PINS A1=B[20] A2=A[20] B=net17584 C=n862 X=net15819
XU1180 SEN_OAOI211_1 $PINS A1=B[24] A2=A[24] B=n359 C=n745 X=net16080
XU1181 SEN_MUXI2_S_0P5 $PINS D0=n551 D1=n368 S=B[23] X=n676
XU1182 SEN_AN2_S_0P5 $PINS A1=n533 A2=n838 X=n520
XU1183 SEN_INV_S_0P5 $PINS A=net16440 X=net16434
XU1184 SEN_NR3_0P5 $PINS A1=net16774 A2=net15790 A3=net15791 X=n877
XU1185 SEN_NR3_0P5 $PINS A1=net16774 A2=n873 A3=n872 X=n874
XU1186 SEN_NR3_0P5 $PINS A1=net16774 A2=net16069 A3=net16070 X=n750
XU1187 SEN_OA21B_1 $PINS A1=net15865 A2=n528 B=n529 X=n761
XU1188 SEN_NR3_T_0P5 $PINS A1=n713 A2=n712 A3=net16772 X=n714
XU1189 SEN_INV_1 $PINS A=n579 X=n742
XU1190 SEN_INV_1 $PINS A=n731 X=n734
XU1191 SEN_NR2_S_0P5 $PINS A1=n723 A2=net16774 X=n724
XU1192 SEN_NR2_S_0P5 $PINS A1=n739 A2=net16774 X=n740
XU1193 SEN_NR2_S_0P5 $PINS A1=n707 A2=net16774 X=n708
XU1194 SEN_NR2_S_0P5 $PINS A1=n886 A2=net16774 X=n888
XU1195 SEN_OAI21_S_0P5 $PINS A1=n732 A2=n579 B=n578 X=n692
XU1196 SEN_NR2_S_0P5 $PINS A1=n716 A2=n581 X=n694
XU1197 SEN_NR2_G_0P5 $PINS A1=n717 A2=n581 X=n693
XU1198 SEN_NR2_S_0P5 $PINS A1=n715 A2=n718 X=n721
XU1199 SEN_NR2_S_0P5 $PINS A1=n728 A2=net16422 X=n729
XU1200 SEN_ND2_S_0P5 $PINS A1=n730 A2=n729 X=net16103
XU1201 SEN_AOI22_0P5 $PINS A1=net18219 A2=n535 B1=n359 B2=n538 X=net16104
XU1202 SEN_ND2_G_1 $PINS A1=n670 A2=n671 X=n868
XU1203 SEN_ND2_S_0P5 $PINS A1=net18219 A2=n537 X=net15762
XU1204 SEN_AN2_S_0P5 $PINS A1=net16501 A2=n542 X=n536
XU1205 SEN_AN3B_0P5 $PINS B1=net16298 B2=net17648 A=net16772 X=n802
XU1206 SEN_ND2_S_0P5 $PINS A1=n576 A2=n725 X=n732
XU1207 SEN_ND2_S_0P5 $PINS A1=n575 A2=n730 X=n717
XU1208 SEN_ND2_S_0P5 $PINS A1=n577 A2=n741 X=n578
XU1209 SEN_INV_S_1 $PINS A=n673 X=n872
XU1210 SEN_ND2_S_0P5 $PINS A1=net16193 A2=net16134 X=n715
XU1211 SEN_OAOI211_1 $PINS A1=B[0] A2=A[0] B=n359 C=n784 X=net15997
XU1212 SEN_OAOI211_1 $PINS A1=B[7] A2=A[7] B=net16444 C=n779 X=net16007
XU1213 SEN_ND2_S_0P5 $PINS A1=net18219 A2=n778 X=net16006
XU1214 SEN_OR3B_0P5 $PINS B1=n697 B2=net16478 A=n696 X=n709
XU1215 SEN_ND2_S_0P5 $PINS A1=net18219 A2=net17000 X=net16066
XU1216 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n859 X=net15818
XU1217 SEN_OAOI211_0P5 $PINS A1=B[18] A2=A[18] B=net17584 C=n844 X=net15848
XU1218 SEN_ND2_S_0P5 $PINS A1=n451 A2=net16999 X=net16145
XU1219 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n856 X=net15831
XU1220 SEN_OAOI211_1 $PINS A1=B[23] A2=A[23] B=n359 C=n877 X=net15786
XU1221 SEN_ND2_S_0P5 $PINS A1=net16434 A2=net17005 X=net15787
XU1222 SEN_OAOI211_1 $PINS A1=B[1] A2=A[1] B=net17584 C=n790 X=net15988
XU1223 SEN_ND2_S_0P5 $PINS A1=net18219 A2=n793 X=net15987
XU1224 SEN_ND2_S_0P5 $PINS A1=net18219 A2=net16084 X=net16079
XU1225 SEN_ND2_S_0P5 $PINS A1=net18219 A2=net15973 X=net15976
XU1226 SEN_OAOI211_0P5 $PINS A1=B[11] A2=A[11] B=net16444 C=n769 X=net16030
XU1227 SEN_ND2_S_0P5 $PINS A1=net18219 A2=n766 X=net16029
XU1228 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n809 X=net15920
XU1229 SEN_OAOI211_0P5 $PINS A1=B[16] A2=A[16] B=net16444 C=n812 X=net15921
XU1230 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n527 X=net15870
XU1231 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n805 X=net15928
XU1232 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n511 S=B[24] X=n678
XU1233 SEN_INV_1 $PINS A=A[3] X=n545
XU1234 SEN_MUXI2_S_0P5 $PINS D0=net16480 D1=net16201 S=A[27] X=n565
XU1235 SEN_MUXI2_S_0P5 $PINS D0=net16482 D1=net16201 S=A[26] X=net16196
XU1236 SEN_INV_1 $PINS A=B[18] X=n540
XU1237 SEN_MUXI2_S_0P5 $PINS D0=net16480 D1=n549 S=A[21] X=n586
XU1238 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n367 S=B[31] X=n699
XU1239 SEN_INV_S_1 $PINS A=net15829 X=net16345
XU1240 SEN_NR3_0P5 $PINS A1=n789 A2=n788 A3=net16422 X=n790
XU1241 SEN_NR3_0P5 $PINS A1=n756 A2=n755 A3=net16772 X=n757
XU1242 SEN_NR3_0P5 $PINS A1=net15979 A2=net15980 A3=net16772 X=n795
XU1243 SEN_NR3_0P5 $PINS A1=net16020 A2=net16021 A3=net16772 X=n774
XU1244 SEN_NR3_T_0P5 $PINS A1=n853 A2=n852 A3=net16774 X=n854
XU1245 SEN_NR3_0P5 $PINS A1=n763 A2=n762 A3=net16772 X=n764
XU1246 SEN_NR3_0P5 $PINS A1=n836 A2=n835 A3=net16774 X=n837
XU1247 SEN_NR3_0P5 $PINS A1=n768 A2=n767 A3=net16772 X=n769
XU1248 SEN_OR2_DG_1 $PINS A1=n832 A2=n758 X=n528
XU1249 SEN_AO21B_1 $PINS A1=n834 A2=n831 B=n760 X=n529
XU1250 SEN_ND2_G_1 $PINS A1=n717 A2=n716 X=n731
XU1251 SEN_EO2_S_0P5 $PINS A1=n709 A2=n707 X=n705
XU1252 SEN_OA2BB2_0P5 $PINS A1=n889 A2=n888 B1=n887 B2=net16448 X=net15763
XU1253 SEN_INV_S_1 $PINS A=net16192 X=net15790
XU1254 SEN_INV_S_1 $PINS A=net16222 X=net16069
XU1255 SEN_INV_S_1 $PINS A=net16223 X=net16070
XU1256 SEN_INV_S_1 $PINS A=n701 X=n707
XU1257 SEN_INV_S_1 $PINS A=n577 X=n739
XU1258 SEN_ND2_G_1 $PINS A1=n565 A2=n564 X=n889
XU1259 SEN_INV_S_1 $PINS A=n353 X=n26
XU1260 SEN_OAOI211_G_1 $PINS A1=B[9] A2=A[9] B=net16444 C=n825 X=net15886
XU1261 SEN_ND2_S_0P5 $PINS A1=net16434 A2=n523 X=net15885
XU1262 SEN_OAOI211_G_1 $PINS A1=B[10] A2=A[10] B=net16444 C=n830 X=net15871
XU1263 SEN_ND2_G_1 $PINS A1=net18219 A2=net15969 X=net15964
XU1264 SEN_OAOI211_G_1 $PINS A1=B[15] A2=A[15] B=net16444 C=n819 X=net15903
XU1265 SEN_EN2_S_1 $PINS A1=n834 A2=n833 X=net15857
XU1266 SEN_ND2_G_1 $PINS A1=net17602 A2=n677 X=net16192
XU1267 SEN_INV_S_1 $PINS A=n352 X=n28
XU1268 SEN_ND2_G_1 $PINS A1=n568 A2=n567 X=n730
XU1269 SEN_MUXI2_S_0P5 $PINS D0=net16480 D1=net16201 S=A[28] X=n568
XU1270 SEN_INV_S_1 $PINS A=n354 X=n24
XU1271 SEN_ND2_S_0P5 $PINS A1=net18219 A2=n814 X=net16038
XU1272 SEN_OAOI211_G_1 $PINS A1=B[12] A2=A[12] B=net17584 C=n757 X=net16053
XU1273 SEN_ND2_S_0P5 $PINS A1=net18219 A2=n360 X=net16052
XU1274 SEN_ND2_G_1 $PINS A1=n571 A2=n570 X=n725
XU1275 SEN_MUXI2_S_0P5 $PINS D0=net16480 D1=net16201 S=A[29] X=n571
XU1276 SEN_INV_S_1 $PINS A=n355 X=n22
XU1277 SEN_MUXI2_S_0P5 $PINS D0=net16480 D1=net16201 S=A[30] X=n574
XU1278 SEN_INV_S_1 $PINS A=n356 X=n20
XU1279 SEN_OR2_1 $PINS A1=A[28] A2=B[28] X=n538
XU1280 SEN_NR2_1 $PINS A1=A[27] A2=B[27] X=n887
XU1281 SEN_ND2_G_1 $PINS A1=net17602 A2=n584 X=n671
XU1282 SEN_ND2_G_1 $PINS A1=net17602 A2=n599 X=net16222
XU1283 SEN_MUXI2_S_0P5 $PINS D0=net16480 D1=n549 S=A[22] X=n599
XU1284 SEN_ND2_G_1 $PINS A1=n555 A2=n687 X=net16193
XU1285 SEN_ND2_G_1 $PINS A1=n553 A2=n569 X=n576
XU1286 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n367 S=B[29] X=n569
XU1287 SEN_ND2_G_1 $PINS A1=n555 A2=n566 X=n575
XU1288 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n367 S=B[28] X=n566
XU1289 SEN_ND2_G_1 $PINS A1=n553 A2=n572 X=n577
XU1290 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n367 S=B[30] X=n572
XU1291 SEN_ND2_G_1 $PINS A1=n553 A2=n562 X=n580
XU1292 SEN_ND2_G_1 $PINS A1=n555 A2=n682 X=n686
XU1293 SEN_ND2_G_1 $PINS A1=n553 A2=n585 X=n673
XU1294 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n368 S=B[21] X=n585
XU1295 SEN_ND2_S_0P5 $PINS A1=n554 A2=n676 X=net16191
XU1296 SEN_ND2_G_1 $PINS A1=n553 A2=n598 X=net16223
XU1297 SEN_MUXI2_S_0P5 $PINS D0=n550 D1=n367 S=B[22] X=n598
XU1298 SEN_ND2B_S_0P5 $PINS A=net16499 B=A[26] X=n352
XU1299 SEN_ND2B_S_0P5 $PINS A=net16499 B=A[27] X=n353
XU1300 SEN_ND2B_S_0P5 $PINS A=net16499 B=A[28] X=n354
XU1301 SEN_ND2B_S_0P5 $PINS A=net16499 B=A[29] X=n355
XU1302 SEN_ND2B_S_0P5 $PINS A=net16499 B=A[30] X=n356
XU1303 SEN_NR3_0P5 $PINS A1=n811 A2=n810 A3=net16772 X=n812
XU1304 SEN_MUXI2_S_1 $PINS D0=n688 D1=n536 S=n28 X=net16197
XU1305 SEN_MUXI2_S_1 $PINS D0=n688 D1=n536 S=n20 X=n573
XU1306 SEN_MUXI2_S_1 $PINS D0=n688 D1=n536 S=n22 X=n570
XU1307 SEN_MUXI2_S_1 $PINS D0=n688 D1=n536 S=n24 X=n567
XU1308 SEN_MUXI2_S_1 $PINS D0=n688 D1=n536 S=n26 X=n564
XU1309 SEN_TIE0_1 $PINS X=*Logic0*
XU1310 SEN_BUF_1 $PINS A=n533 X=n539
XU1311 SEN_BUF_1 $PINS A=n703 X=n542
XU1312 SEN_INV_S_0P5 $PINS A=net16179 X=net16178
XU1313 SEN_BUF_1 $PINS A=net15941 X=net16723
XU1314 SEN_MUXI2_S_0P5 $PINS D0=net16200 D1=n549 S=A[23] X=n677
XU1315 SEN_INV_S_0P5 $PINS A=n583 X=n688
XU1316 SEN_ND3_S_0P5 $PINS A1=net16311 A2=net16968 A3=n695 X=n621
XU1317 SEN_INV_S_1 $PINS A=net16774 X=net16424
XU1318 SEN_OAI21_S_0P5 $PINS A1=net18246 A2=net16178 B=A[31] X=n696
XU1319 SEN_ND2_G_1 $PINS A1=net16434 A2=net15953 X=net15948
XU1320 SEN_ND2_S_0P65 $PINS A1=net16434 A2=net16701 X=net15937
XU1321 SEN_NR3_0P5 $PINS A1=n783 A2=n782 A3=net15769 X=n784
XU1322 SEN_INV_S_1 $PINS A=net16424 X=net16422
.ENDS
