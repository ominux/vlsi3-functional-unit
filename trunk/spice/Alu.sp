$ Spice netlist generated by v2lvs
$ v2007.1_31.29    Wed Apr  4 12:35:05 PDT 2007
.INCLUDE "design_model.inc"

.SUBCKT Alu Z[31] Z[30] Z[29] Z[28] Z[27] Z[26] Z[25] Z[24] Z[23] Z[22] Z[21]
+ Z[20] Z[19] Z[18] Z[17] Z[16] Z[15] Z[14] Z[13] Z[12] Z[11] Z[10] Z[9] Z[8]
+ Z[7] Z[6] Z[5] Z[4] Z[3] Z[2] Z[1] Z[0] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31]
+ B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18]
+ B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4]
+ B[3] B[2] B[1] B[0] INST[3] INST[2] INST[1] INST[0] FLAGS[3] FLAGS[2]
+ FLAGS[1] FLAGS[0]
XU416 n364 n362 SEN_INV_2
XU417 n363 n362 SEN_INV_2
XU418 n592 n540 A[8] SEN_ND2_G_1
XU419 n907 n701 n700 SEN_ND2_G_1
XU420 n939 n623 n622 SEN_ND2_G_1
XU421 n610 n536 n609 SEN_ND2_G_1
XU422 n978 n985 SEN_INV_S_1
XU423 n737 n736 n779 n735 SEN_ND3_S_0P5
XU424 n735 n533 n734 SEN_ND2_G_1
XU425 n825 n738 n546 SEN_NR2_1
XU426 n756 n755 n779 n754 SEN_ND3_S_0P5
XU427 n754 n533 n753 SEN_ND2_G_1
XU428 n861 n751 n546 SEN_NR2_1
XU429 n820 n862 n861 SEN_NR2_1
XU430 n761 n760 n779 n759 SEN_ND3_S_0P5
XU431 n759 n533 n758 SEN_ND2_G_1
XU432 n782 n793 SEN_INV_S_1
XU433 n552 n1057 SEN_INV_S_1
XU434 n1053 n1010 SEN_INV_S_1
XU435 n919 n917 n918 SEN_EO2_G_2
XU436 n850 n851 n858 SEN_NR2_1
XU437 n914 n916 n915 SEN_EO2_2
XU438 n496 n914 SEN_INV_S_1
XU439 n548 n1036 SEN_INV_2
XU440 n806 n778 SEN_INV_S_1
XU441 n366 n1010 SEN_INV_S_1
XU442 n810 n805 n778 SEN_EO2_S_0P5
XU443 n551 n552 SEN_INV_S_1
XU444 n553 n556 SEN_INV_2
XU445 n796 n792 n782 SEN_EO2_S_0P5
XU446 n799 n806 n805 SEN_NR2_1
XU447 n788 n796 SEN_INV_S_1
XU448 n787 n799 SEN_INV_S_1
XU449 n550 n552 SEN_INV_S_1
XU450 n1044 n786 n790 SEN_NR2_2
XU451 n549 n548 SEN_INV_S_1
XU452 n676 n955 n954 SEN_NR2_1
XU453 n661 n656 n840 SEN_ND2_2
XU454 n616 n554 A[3] SEN_EO2_S_0P5
XU455 n389 n1031 n388 SEN_NR2_2
XU456 n602 n554 A[14] SEN_EO2_S_0P5
XU457 n430 n555 A[15] SEN_EO2_S_0P5
XU458 n1051 n638 n553 n789 SEN_OAI21_G_1
XU459 n1047 n534 A[0] SEN_NR2_1
XU460 n634 n944 SEN_INV_S_1
XU461 n999 n592 n591 n590 SEN_ND3_T_2
XU462 n591 n533 n588 n365 SEN_AOI21_S_1
XU463 n472 n654 SEN_INV_2
XU464 n469 n389 n935 SEN_NR2_1
XU465 n568 n555 A[9] SEN_EO2_S_0P5
XU466 n555 n556 SEN_INV_2
XU467 n791 n789 n1050 SEN_ND2_2
XU468 n986 n678 n546 SEN_NR2_1
XU469 n909 n914 n908 SEN_ND2_G_1
XU470 n885 n905 n896 n901 n900 SEN_OAI22_1
XU471 n886 n905 n977 SEN_NR2_1
XU472 n745 n744 n779 n743 SEN_ND3_S_0P5
XU473 n871 n740 n546 SEN_NR2_1
XU474 n778 n777 n776 n775 SEN_ND3_S_0P5
XU475 n774 n553 A[30] SEN_EO2_S_0P5
XU476 n502 Z[29] SEN_INV_S_1
XU477 n1008 n358 n1007 SEN_EO2_S_0P5
XU478 n997 n998 SEN_INV_S_1
XU479 n990 n996 n989 SEN_EO2_S_0P5
XU480 n441 n989 n996 n930 SEN_OAI21_G_1
XU481 n439 n933 n1036 SEN_NR2_1
XU482 n440 n931 n932 n1010 SEN_AN3B_1
XU483 n917 n584 n545 SEN_NR2_T_1
XU484 n426 n919 n419 SEN_EO2_S_0P5
XU485 n988 n906 SEN_INV_S_1
XU486 n979 n978 n414 SEN_EO2_S_0P5
XU487 n985 n980 n981 SEN_EO2_1
XU488 n446 n527 n549 SEN_NR2_1
XU489 n977 n972 n973 SEN_EO2_1
XU490 n892 n889 n890 SEN_EO2_1
XU491 n874 n871 n872 SEN_EO2_S_0P5
XU492 n866 n860 SEN_INV_S_1
XU493 n769 n768 n779 n767 SEN_ND3_S_0P5
XU494 n765 n553 A[29] SEN_EO2_S_0P5
XU495 FLAGS[1] n785 n788 n784 SEN_AO21B_1
XU496 n1042 n1041 n548 SEN_ND2_G_1
XU497 n1030 n525 n1029 SEN_EO2_S_0P5
XU498 Z[14] n1036 n858 n857 n856 SEN_OAI211_1
XU499 n857 n852 n367 SEN_ND2_G_1
XU500 n848 n850 n847 n846 n845 SEN_OAOI211_G_1
XU501 Z[18] n490 n1044 n491 SEN_OAI21_G_1
XU502 n490 n496 n497 SEN_EO2_1
XU503 Z[25] n399 n1044 n400 n401 SEN_OAI211_1
XU504 n401 n868 n548 SEN_ND2_G_1
XU505 Z[28] n403 n1044 n404 SEN_OAI21_G_1
XU506 n404 n823 n548 n405 SEN_AOI21B_1
XU507 n403 n823 n408 SEN_EO2_S_0P5
XU508 n408 n859 n860 n409 SEN_AOI21B_1
XU509 Z[31] n800 n516 SEN_ND2_G_1
XU510 n516 n802 n801 SEN_OR2_1
XU511 n800 n802 n799 n798 n797 SEN_OAOI211_G_1
XU512 n801 n788 n1058 n787 SEN_ND3_S_0P5
XU513 n896 n972 n973 SEN_ND2B_1
XU514 n348 n541 SEN_INV_0P5
XU515 n349 n543 B[31] SEN_NR2_0P5
XU516 n792 B[31] n348 n547 n349 SEN_AOI211_0P5
XU517 n1055 n1048 n364 n1047 SEN_NR3B_1
XU518 n930 n991 n992 SEN_ND2B_1
XU519 n350 n541 SEN_INV_0P5
XU520 n351 n361 B[28] SEN_NR2_0P5
XU521 n821 B[28] n350 n546 n351 SEN_AOI211_0P5
XU522 n785 n802 n787 SEN_ND2B_1
XU523 n784 n792 n782 SEN_ND2B_1
XU524 n1036 n789 n529 n790 SEN_OR3_1
XU525 n352 A[19] B[19] n551 SEN_OAI21_0P5
XU526 n447 n912 n911 n366 n352 SEN_OAI31_0P5
XU527 n1062 n1054 n1055 SEN_EO2_S_0P5
XU528 n1012 n624 n1011 n1010 SEN_AN3_0P5
XU529 n959 n955 n954 SEN_EN2_S_2
XU530 n353 n541 SEN_INV_0P5
XU531 n354 n361 B[29] SEN_NR2_0P5
XU532 n814 B[29] n353 n547 n354 SEN_AOI211_0P5
XU533 n355 n1050 n1051 SEN_ND2_0P5
XU534 n1061 n1050 n1049 n355 n1052 SEN_OAI211_0P5
XU535 n843 n842 n373 n1010 SEN_ND3B_0P5
XU536 n860 n862 n861 SEN_EO2_S_0P5
XU537 n356 n541 SEN_INV_0P5
XU538 n357 n543 B[30] SEN_NR2_0P5
XU539 n805 B[30] n356 n547 n357 SEN_AOI211_0P5
XU540 n360 n421 SEN_INV_5
XU541 n937 n1037 n1041 SEN_ND2_T_5
XU542 n1037 n642 n1048 n1054 n641 SEN_AOI22_2
XU543 n962 n1007 n358 n942 SEN_OAI21_G_2
XU544 n1038 n643 n545 SEN_NR2_2
XU545 n554 n556 SEN_INV_4
XU546 Z[5] n1036 n358 n1014 n1013 SEN_OAI211_2
XU547 Z[0] n1062 n1061 n1060 n1059 SEN_OAI211_2
XU548 n367 n1044 SEN_INV_S_1
XU549 n358 n1009 n1011 SEN_EO2_S_0P5
XU550 n556 A[31] SEN_INV_2
XU551 n442 n933 n441 SEN_EN2_0P5
XU552 n504 n506 SEN_INV_3
XU553 FLAGS[0] n785 n784 n783 SEN_OAI21_G_1
XU554 n507 Z[28] Z[14] SEN_NR2_T_1P5
XU555 Z[15] n850 n374 n849 n848 SEN_OAI31_1
XU556 Z[24] n448 n444 n449 SEN_OAI21_T_2
XU557 n835 n830 n1058 SEN_ND2_2
XU558 n888 n887 n886 n885 SEN_AOI21_S_2
XU559 n418 n411 n827 SEN_ND2_3
XU560 n989 n410 n929 SEN_NR2_T_2
XU561 n411 n410 n412 n413 SEN_OAI21_4
XU562 n499 Z[4] SEN_INV_0P65
XU563 n397 n880 n881 n884 SEN_AOI21_S_2
XU564 n798 n788 n1044 SEN_NR2_0P65
XU565 n846 n841 n1044 SEN_NR2_G_0P8
XU566 n1028 n938 SEN_INV_1
XU567 n926 B[11] A[11] n550 n923 SEN_OAOI211_G_1
XU568 n457 A[3] B[3] n550 n458 SEN_OAOI211_G_1
XU569 n957 B[20] A[20] n550 n956 SEN_OAOI211_G_1
XU570 n748 n747 n746 SEN_ND2_2
XU571 n898 n905 SEN_INV_2
XU572 n864 A[27] B[27] n551 n863 SEN_OAOI211_G_1
XU573 n526 n625 SEN_INV_1
XU574 n749 n868 n867 n874 SEN_OAI21_G_2
XU575 n829 n918 n585 SEN_ND2_3
XU576 n876 B[26] A[26] n551 n873 SEN_OAOI211_G_1
XU577 n894 A[23] B[23] n551 n891 SEN_OAOI211_G_1
XU578 n400 B[25] A[25] n551 n402 SEN_OAOI211_G_1
XU579 n451 n884 n549 SEN_NR2_G_1
XU580 n460 n828 SEN_INV_S_1
XU581 n492 n914 n549 SEN_NR2_G_1
XU582 n856 B[14] A[14] n551 n855 SEN_OAOI211_G_1
XU583 n374 n842 n373 SEN_EO2_3
XU584 n794 n793 n792 n366 SEN_NR3_T_0P65
XU585 n762 n821 SEN_INV_1
XU586 n771 n815 SEN_INV_1
XU587 n938 n1026 n1027 SEN_EO2_4
XU588 n747 n871 SEN_INV_1
XU589 n406 n821 n366 SEN_NR2_1
XU590 n905 n900 n718 SEN_EO2_8
XU591 n824 n883 n882 SEN_NR2_G_2
XU592 n867 n826 n825 SEN_NR2_G_1
XU593 n494 n915 n1010 SEN_ND2_S_0P5
XU594 n831 n600 n545 SEN_NR2_T_2
XU595 n1026 n622 SEN_INV_2
XU596 n388 n455 n545 SEN_NR2_T_3
XU597 n980 n684 n546 SEN_NR2_S_3
XU598 n882 n727 n546 SEN_NR2_G_2
XU599 n900 n706 n546 SEN_NR2_S_3
XU600 n673 n672 n779 n671 SEN_ND3_T_2
XU601 n545 n360 SEN_INV_16
XU602 n918 n583 n582 n581 SEN_ND3_T_2
XU603 n612 n372 A[6] SEN_ND2_2
XU604 n779 n363 SEN_INV_8
XU605 n641 n640 SEN_INV_1
XU606 n947 B[6] A[6] n551 SEN_OAI21_G_1
XU607 n362 n1046 SEN_INV_6
XU608 n464 A[5] n554 SEN_EO2_2
XU609 n720 n553 A[23] SEN_EO2_S_1
XU610 n742 A[26] SEN_INV_1
XU611 n670 A[20] SEN_INV_1
XU612 n505 n504 n502 n501 n507 SEN_ND4_S_6
XU613 Z[30] n809 n517 SEN_ND2_T_2
XU614 n809 n804 n367 SEN_ND2_2
XU615 Z[29] n819 n549 n818 n817 SEN_OAI211_2
XU616 n802 n803 n810 SEN_NR2_T_4
XU617 Z[22] n904 n519 SEN_ND2_T_2
XU618 n895 n892 n888 SEN_EO2_2
XU619 n904 n899 n367 SEN_ND2_2
XU620 n958 n953 n1058 SEN_ND2_2
XU621 n468 n937 n469 n470 n471 SEN_AOAI211_G_3
XU622 n880 n885 n892 n726 n725 SEN_AOI22_T_3
XU623 n415 n978 n909 SEN_AN2_1
XU624 n849 n840 n367 SEN_ND2_G_0P65
XU625 n929 n928 SEN_INV_1
XU626 n657 n460 n827 n829 SEN_ND3_T_2
XU627 n1033 A[2] B[2] n550 n1032 SEN_OAOI211_G_1
XU628 n975 A[21] B[21] n550 n974 SEN_OAOI211_1
XU629 n1059 n1058 n1061 n548 n1062 SEN_AOAI211_1
XU630 n1043 A[1] B[1] n550 n1040 SEN_OAOI211_G_1
XU631 n763 n823 n820 n359 n762 SEN_AOI22_T_1
XU632 n424 B[12] A[12] n550 n425 SEN_OAOI211_1
XU633 n994 A[9] B[9] n550 n993 SEN_OAOI211_1
XU634 n983 A[17] B[17] n550 n982 SEN_OAOI211_1
XU635 n521 n985 n549 SEN_OR2_1
XU636 n698 n950 n676 SEN_NR2_G_1
XU637 n405 n359 n406 n551 n407 SEN_AOI22_1
XU638 n1056 n1055 n1054 n1053 SEN_NR3_1
XU639 n725 n889 SEN_INV_1
XU640 n726 n890 SEN_INV_1
XU641 n696 n980 SEN_INV_1
XU642 n523 n911 SEN_INV_2
XU643 n812 n814 n815 SEN_EO2_G_2
XU644 n770 n814 SEN_INV_2
XU645 n493 n494 n916 n495 SEN_OAI21_G_1
XU646 n956 n955 n954 n366 SEN_NR3_1
XU647 n863 n862 n861 n366 SEN_NR3_T_0P65
XU648 n746 n872 SEN_INV_0P8
XU649 n816 n815 n814 n366 SEN_NR3_T_0P65
XU650 n889 n719 n546 SEN_NR2_G_2
XU651 n991 n572 n545 SEN_NR2_T_2
XU652 n842 n594 n545 SEN_NR2_T_2
XU653 n1001 n587 n545 SEN_NR2_T_3
XU654 n911 n668 n546 SEN_NR2_T_2
XU655 n972 n712 n546 SEN_NR2_T_2
XU656 n954 n674 n546 SEN_NR2_S_4
XU657 n718 n711 n710 n709 SEN_ND3_T_2
XU658 n739 n732 n731 n730 SEN_ND3_T_2
XU659 n1000 A[8] B[8] n550 SEN_OAI21_G_1
XU660 n1018 A[4] B[4] n550 SEN_OAI21_G_1
XU661 n495 B[18] A[18] n551 SEN_OAI21_G_1
XU662 n444 n367 SEN_INV_1
XU663 n365 n362 SEN_INV_3
XU664 n371 n376 n377 SEN_ND2_T_6
XU665 n580 n555 A[12] SEN_EO2_1
XU666 n421 n1049 n420 SEN_NR2_T_2
XU667 n1058 n1044 SEN_INV_0P5
XU668 n1050 n529 SEN_INV_5
XU669 n638 n531 SEN_INV_2
XU670 n685 A[17] SEN_INV_0P8
XU671 n465 A[5] SEN_INV_1
XU672 n713 A[21] SEN_INV_0P8
XU673 n384 A[4] SEN_INV_1
XU674 n601 A[14] SEN_INV_0P8
XU675 n579 A[12] SEN_INV_0P8
XU676 FLAGS[2] Z[31] n505 Z[30] SEN_NR3_T_2
XU677 n501 Z[15] SEN_INV_1
XU678 n510 n511 Z[18] Z[10] Z[11] SEN_OR4B_2
XU679 n818 n813 n1058 SEN_ND2_2
XU680 Z[13] n1036 n836 n835 n834 SEN_OAI211_2
XU681 n869 n394 SEN_INV_S_2
XU682 n811 n764 n763 SEN_ND2_T_2
XU683 Z[21] n976 n975 n520 SEN_ND3_T_2
XU684 n394 n398 n824 SEN_NR2_S_4
XU685 Z[17] n984 n983 n521 SEN_ND3_T_2
XU686 n416 n500 Z[16] SEN_NR2B_V1_2
XU687 n851 n839 n838 n837 SEN_AOI21_G_2
XU688 Z[11] n927 n1044 n926 n925 SEN_OAI211_2
XU689 n897 n970 n977 n896 SEN_OAI21_G_2
XU690 n398 n393 SEN_INV_S_2
XU691 n390 n467 n468 SEN_ND2_4
XU692 Z[4] n1024 n1044 n1023 SEN_OAI21_0P75
XU693 n471 n472 n655 SEN_NR2_S_4
XU694 n445 n446 n447 SEN_NR2_G_2
XU695 n479 n481 n661 SEN_NR2_G_2
XU696 n1013 B[5] A[5] n550 n1012 SEN_OAOI211_1
XU697 n607 n829 SEN_INV_1
XU698 n417 n988 n549 SEN_OR2_1
XU699 n702 n699 SEN_INV_1
XU700 n449 n551 n450 n451 n452 SEN_AOI211_G_2
XU701 n498 n913 SEN_INV_1
XU702 n378 n942 n940 SEN_ND2_3
XU703 n491 n492 n493 SEN_NR2_G_1
XU704 n481 n998 n928 n933 n996 SEN_AOI211_3
XU705 n437 n550 n438 n439 n440 SEN_AOI211_G_2
XU706 n1005 n1004 n1003 SEN_NR2_G_1
XU707 n881 n886 n892 SEN_ND2_2
XU708 n819 n812 SEN_INV_1
XU709 n487 n660 SEN_INV_1
XU710 n795 n553 B[31] n550 n794 SEN_OAOI211_1
XU711 n409 n820 SEN_INV_1
XU712 n808 B[30] A[30] n551 n807 SEN_OAOI211_1
XU713 n750 n867 n824 SEN_NR2_G_1
XU714 n520 n977 n549 SEN_OR2_1
XU715 n470 n466 n389 SEN_NR2_G_2
XU716 n875 n874 n548 SEN_ND2_2
XU717 n677 n676 SEN_INV_1
XU718 n903 A[22] B[22] n551 n902 SEN_OAOI211_1
XU719 n840 n847 SEN_INV_4
XU720 n893 n892 n548 SEN_ND2_2
XU721 n817 A[29] B[29] n551 n816 SEN_OAOI211_1
XU722 n834 B[13] A[13] n551 n833 SEN_OAOI211_1
XU723 n836 n838 SEN_INV_1
XU724 n434 A[16] B[16] n550 n435 SEN_OAOI211_1
XU725 n1035 n525 SEN_INV_1
XU726 n920 n924 SEN_INV_1
XU727 n1060 A[0] B[0] n551 n1056 SEN_OAOI211_1
XU728 n1041 n1038 n1039 SEN_EO2_4
XU729 n522 n947 n946 SEN_AN2_1
XU730 n402 n826 n825 n366 SEN_NR3_1
XU731 n466 n388 n1031 SEN_EO2_2
XU732 n823 n821 n822 SEN_EO2_2
XU733 n828 n922 n921 SEN_NR2_T_2
XU734 n586 n931 SEN_INV_1
XU735 n452 n883 n882 n366 SEN_NR3_1
XU736 n807 n806 n805 n366 SEN_NR3_1
XU737 n833 n832 n831 n366 SEN_NR3_1
XU738 n837 n832 n831 SEN_NR2_G_3
XU739 n701 n986 SEN_INV_1
XU740 n697 n916 SEN_INV_1
XU741 n700 n987 SEN_INV_1
XU742 n884 n882 n739 SEN_EO2_2
XU743 n891 n890 n889 n366 SEN_NR3_1
XU744 n923 n922 n921 n1053 SEN_NR3_1
XU745 n868 n825 n826 SEN_EO2_2
XU746 n660 n432 n842 SEN_NR2_T_2
XU747 n435 n987 n986 n1053 SEN_NR3_1
XU748 n873 n872 n871 n366 SEN_NR3_1
XU749 n902 n901 n900 n1053 SEN_NR3_1
XU750 n901 n718 SEN_INV_1
XU751 n359 n822 SEN_INV_1
XU752 n883 n739 SEN_INV_1
XU753 n969 n965 n966 SEN_EN2_S_3
XU754 n724 n723 n779 n722 SEN_ND3_1
XU755 n973 n717 n716 n715 SEN_ND3_T_2
XU756 n533 n534 SEN_INV_6
XU757 n361 n544 SEN_INV_10
XU758 n844 B[15] A[15] n1057 SEN_OAI21_S_0P5
XU759 n729 n553 A[24] SEN_EO2_1
XU760 n781 n786 n557 SEN_ND2_3
XU761 n650 A[2] SEN_INV_1
XU762 n407 A[28] B[28] SEN_OR2_1
XU763 n753 A[27] SEN_INV_1
XU764 n772 A[30] SEN_INV_0P8
XU765 n450 A[24] B[24] SEN_OR2_1
XU766 n645 A[1] SEN_INV_1
XU767 n664 A[19] SEN_INV_0P8
XU768 n707 A[22] SEN_INV_0P65
XU769 n574 A[11] SEN_INV_1
XU770 n561 A[10] SEN_INV_0P8
XU771 n588 A[8] SEN_INV_0P8
XU772 n627 A[7] SEN_INV_0P65
XU773 n438 A[10] B[10] SEN_OR2_1
XU774 n758 A[28] SEN_INV_1
XU775 n721 A[23] SEN_INV_1
XU776 n596 A[13] SEN_INV_1
XU777 n567 A[9] SEN_INV_0P8
XU778 n680 A[16] SEN_INV_1
XU779 n728 A[24] SEN_INV_0P8
XU780 n691 A[18] SEN_INV_0P65
XU781 n766 A[29] SEN_INV_1
XU782 n431 A[15] SEN_INV_0P8
XU783 n734 A[25] SEN_INV_1
XU784 n615 A[3] SEN_INV_0P8
XU785 n620 B[3] SEN_INV_1
XU786 n613 B[6] SEN_INV_1
XU787 n608 A[6] SEN_INV_0P8
XU788 n632 B[7] SEN_INV_1
XU789 n614 n542 n544 n613 SEN_MUXI2_S_3
XU790 n544 n781 SEN_INV_6
XU791 n1009 n422 n545 SEN_NR2_T_3
XU792 n674 n361 n541 B[20] SEN_MUXI2_S_2
XU793 n455 n543 n387 B[2] SEN_MUXI2_S_2
XU794 n945 n612 n611 n610 SEN_ND3_T_2
XU795 n859 n393 n750 n749 n748 SEN_AOAI211_G_4
XU796 n462 n532 n465 n364 SEN_AOI21_2
XU797 Z[7] n1036 n969 n968 n967 SEN_OAI211_2
XU798 n964 n969 n963 SEN_EO2_1
XU799 n611 n532 n608 n364 SEN_AOI21_S_1
XU800 n1032 n1031 n388 n1053 SEN_NR3_G_1
XU801 n368 Z[24] Z[19] SEN_NR2_T_1P5
XU802 n514 Z[23] Z[12] n369 SEN_NR3_T_3
XU803 n369 n368 SEN_INV_2
XU804 Z[12] n549 n919 n423 n424 SEN_OAI211_2
XU805 n508 n514 n515 n503 SEN_ND3_T_2
XU806 Z[23] n895 n1044 n894 n893 SEN_OAI211_3
XU807 n414 n391 n988 n907 SEN_OAI21_3
XU808 n877 n874 n870 SEN_EO2_2
XU809 n432 n373 SEN_INV_2
XU810 n373 n427 n428 n429 SEN_ND3_T_2
XU811 n370 INST[3] SEN_BUF_6
XU812 n375 n530 n531 n370 SEN_ND3_T_0P8
XU813 n557 n531 n370 SEN_ND2_4
XU814 n1052 n370 SEN_INV_8
XU815 n560 n370 n530 SEN_ND2_T_4
XU816 n790 n531 n370 SEN_ND2B_1
XU817 n640 n1051 n1050 n370 SEN_AOI21_S_1
XU818 n372 n371 SEN_INV_10
XU819 n540 n371 SEN_INV_4
XU820 n539 n371 SEN_INV_6
XU821 n427 n372 A[15] SEN_ND2_G_1
XU822 n461 n372 A[5] SEN_ND2_4
XU823 n631 n372 A[7] SEN_ND2_T_1P5
XU824 n619 n372 A[3] SEN_ND2_G_4
XU825 n955 n372 A[20] n673 SEN_AOI21_T_2
XU826 n566 n372 A[10] SEN_ND2_G_1
XU827 n571 n372 A[9] SEN_ND2_G_1
XU828 n689 n372 A[17] SEN_ND2_G_1
XU829 n695 n372 A[18] SEN_ND2_G_1
XU830 n711 n372 A[22] SEN_ND2_G_1
XU831 n717 n372 A[21] SEN_ND2_G_1
XU832 n732 n372 A[24] SEN_ND2_G_1
XU833 n777 n372 A[30] SEN_ND2_G_1
XU834 n987 n372 A[16] n683 SEN_AOI21_T_1
XU835 n486 n840 n858 n374 n487 SEN_AOAI211_3
XU836 n845 n374 n549 n844 n843 SEN_OAI211_1
XU837 n841 n374 SEN_INV_S_1
XU838 n377 n560 n638 n1050 SEN_AO21_4
XU839 n376 n562 n530 n375 SEN_OA21_2
XU840 n636 n966 n965 SEN_ND2_4
XU841 n379 n636 SEN_INV_3
XU842 n654 n378 n379 SEN_NR2_T_4
XU843 n380 n791 SEN_INV_3
XU844 n538 n562 n380 SEN_ND2B_V1_6
XU845 n385 n554 A[4] SEN_EO2_2
XU846 n383 n533 n384 SEN_ND2_G_1
XU847 n382 n536 n385 SEN_ND2_G_1
XU848 n381 n382 n383 n779 SEN_ND3_T_2
XU849 n1020 n539 A[4] n381 SEN_AOI21_T_3
XU850 n1019 n545 n386 SEN_NR2_T_4
XU851 n386 n361 n387 B[4] SEN_MUXI2_S_4
XU852 n1022 n1019 n1020 SEN_EO2_2
XU853 n542 n454 n557 SEN_AN2_6
XU854 n387 n542 SEN_INV_10
XU855 n541 n542 SEN_INV_4
XU856 n422 n361 n387 B[5] SEN_MUXI2_DG_2
XU857 n643 n361 n387 B[1] SEN_MUXI2_DG_2
XU858 n578 n361 n387 B[11] SEN_MUXI2_S_2
XU859 n558 n543 n387 B[10] SEN_MUXI2_S_2
XU860 n639 n543 n387 B[0] SEN_MUXI2_S_2
XU861 n606 n361 n387 B[14] SEN_MUXI2_S_2
XU862 n668 n543 n387 B[19] SEN_MUXI2_S_1
XU863 n600 n543 n387 B[13] SEN_MUXI2_S_1
XU864 n594 n543 n387 B[15] SEN_MUXI2_S_1
XU865 n587 n361 n387 B[8] SEN_MUXI2_S_1
XU866 n584 n361 n387 B[12] SEN_MUXI2_S_1
XU867 n572 n543 n387 B[9] SEN_MUXI2_S_1
XU868 n525 n388 n1031 SEN_EO2_2
XU869 n410 n390 n998 SEN_NR2_T_4
XU870 n483 n390 n488 SEN_ND2_T_4
XU871 n1006 n997 n390 SEN_EO2_S_0P5
XU872 n391 n482 n483 n484 SEN_ND3_T_4
XU873 n392 n391 n395 SEN_NR2_T_3
XU874 n436 n988 n391 SEN_EO2_1
XU875 n393 n392 n396 n397 SEN_OAI21_S_4
XU876 n970 n392 n879 SEN_NR2_T_4
XU877 n399 n868 n394 SEN_EO2_1
XU878 n509 Z[20] Z[25] n510 Z[27] SEN_NR4_6
XU879 n395 n703 n906 n699 SEN_ND3_T_1
XU880 n396 n878 n880 SEN_ND2_T_1P5
XU881 n413 n996 n930 n933 SEN_AOI21_S_1
XU882 n412 n928 n930 SEN_ND2_G_1
XU883 n419 n418 n924 n828 SEN_AOI21_S_4
XU884 n497 n414 n978 n498 SEN_AOI21_3
XU885 n951 n414 n415 n910 n909 SEN_AOI22_T_3
XU886 Z[16] n434 n433 n417 SEN_ND3_T_2
XU887 n512 n416 n499 n513 SEN_ND3_T_2
XU888 n927 n920 n418 SEN_EO2_1
XU889 n839 n419 n919 n829 SEN_OAI21_3
XU890 n1049 n638 n789 SEN_ND2_2
XU891 n420 n1052 n529 SEN_ND2_G_1
XU892 n425 n917 n918 n1010 SEN_AN3B_1
XU893 n423 n426 n367 SEN_ND2_2
XU894 n429 n536 n430 SEN_ND2_G_1
XU895 n428 n533 n431 n364 SEN_AOI21_S_1
XU896 n433 n436 n367 SEN_ND2_2
XU897 Z[10] n442 n367 n437 SEN_AO21B_2
XU898 n443 n527 n951 SEN_EN2_3
XU899 Z[19] n443 n444 n445 SEN_OAI21_3
XU900 n453 n970 n881 n880 SEN_OA21_2
XU901 n448 n884 n453 SEN_EN2_3
XU902 n454 n1052 n529 n530 SEN_MUXI2_S_4
XU903 n1025 n1029 n525 n389 SEN_AOI21_3
XU904 n458 n1027 n1026 n1053 SEN_NR3_G_1
XU905 n459 n1028 n1025 SEN_EO2_S_0P5
XU906 n456 n459 n1058 SEN_ND2_G_1
XU907 Z[3] n1036 n1028 n456 n457 SEN_OAI211_1
XU908 n658 n930 n933 SEN_NR2_T_3
XU909 n1011 n461 n462 n463 SEN_ND3_T_4
XU910 n463 n536 n464 SEN_ND2_4
XU911 n1015 n1009 n1011 SEN_EO2_2
XU912 n477 n969 n636 SEN_ND2_G_3
XU913 n476 n934 n635 n636 SEN_ND3_2
XU914 n475 n1015 n635 n636 n942 SEN_ND4_1
XU915 n474 n475 n476 n477 SEN_ND3_T_2
XU916 n473 n655 n938 n1022 n960 SEN_OAI22_3
XU917 n467 n473 n654 n474 SEN_AOI21_3
XU918 n489 n656 n928 n840 SEN_ND3_2
XU919 n485 n661 n838 n486 SEN_OAI21_G_2
XU920 n488 n489 n658 n657 SEN_NR3_T_3
XU921 n480 n924 n828 SEN_NR2_1
XU922 n478 n658 n657 SEN_NR2_2
XU923 n484 n662 n919 n485 SEN_AOI21_T_2
XU924 n482 n478 n479 n662 n480 SEN_AOI22_T_2
XU925 n513 Z[3] Z[2] Z[1] Z[0] SEN_NR4_3
XU926 n500 Z[8] SEN_INV_S_1
XU927 n511 n512 Z[5] Z[9] SEN_NR3_T_2
XU928 n503 Z[22] Z[21] Z[17] Z[6] SEN_NR4_3
XU929 n515 Z[7] SEN_INV_S_1
XU930 n506 n509 n508 Z[26] Z[13] SEN_OR4B_4
XU931 n517 n810 n549 n808 SEN_OA21_1
XU932 n518 n866 n859 SEN_EN2_S_2
XU933 n865 n518 n367 SEN_ND2_2
XU934 n519 n549 n905 n903 SEN_OA21_1
XU935 Z[6] n949 n522 n948 SEN_ND3_S_4
XU936 n524 n675 SEN_INV_2
XU937 n527 n523 n524 SEN_EO2_5
XU938 n786 n530 n529 SEN_AN2_S_3
XU939 n1031 n539 A[2] n653 SEN_AOI21_G_4
XU940 n916 n690 n546 SEN_NR2_T_3
XU941 n803 n811 n812 n771 n770 SEN_AOI22_T_3
XU942 n534 n773 SEN_INV_5
XU943 n628 n554 A[7] SEN_EO2_1
XU944 n1046 n560 n559 SEN_NR2_T_4
XU945 n789 n530 SEN_INV_3
XU946 n644 n554 A[1] SEN_EO2_1
XU947 n532 n534 SEN_INV_S_12
XU948 n623 n619 n618 n617 SEN_ND3_T_2
XU949 n617 n536 n616 SEN_ND2_T_1
XU950 n960 n635 SEN_INV_4
XU951 n562 n1052 n531 SEN_ND2_T_2
XU952 n827 n932 n586 SEN_ND2_2
XU953 n928 n999 n593 SEN_ND2_G_4
XU954 n773 n559 n530 SEN_NR2_T_2
XU955 n622 n621 n360 SEN_ND2_T_1P5
XU956 n921 n578 n545 SEN_NR2_T_3
XU957 n847 n854 n853 SEN_NR2_S_5
XU958 n992 n571 n570 n569 SEN_ND3_T_2
XU959 n530 INST[1] SEN_BUF_6
XU960 n942 n1011 n624 SEN_ND2_S_4
XU961 n967 n1010 n965 n966 n528 SEN_AOI31_0P5
XU962 n656 n660 n837 SEN_NR2_T_4
XU963 n703 n698 n527 n677 n959 SEN_AOI22_T_1P5
XU964 Z[20] n959 n549 n958 n957 SEN_OAI211_3
XU965 n585 n917 SEN_INV_2
XU966 n662 n661 n607 SEN_NR2_S_5
XU967 n635 n945 n944 SEN_ND2_G_3
XU968 n934 n634 n945 SEN_EO2_2
XU969 n609 n554 A[6] SEN_EO2_2
XU970 n1039 n539 A[1] n648 SEN_AOI21_T_3
XU971 n624 n1009 SEN_INV_3
XU972 n870 n869 n868 n867 SEN_AOI21_3
XU973 Z[26] n877 n1044 n876 n875 SEN_OAI211_3
XU974 n966 n631 n630 n629 SEN_ND3_T_3
XU975 n629 n536 n628 SEN_ND2_T_1
XU976 n543 n544 SEN_INV_12
XU977 n593 n1001 SEN_INV_S_2
XU978 n998 n1001 n999 SEN_EO2_5
XU979 n915 n695 n694 n693 SEN_ND3_S_4
XU980 n727 n543 n541 B[24] SEN_MUXI2_S_1
XU981 n719 n361 n541 B[23] SEN_MUXI2_S_1
XU982 n672 n535 n669 SEN_ND2_G_1
XU983 n535 n538 SEN_INV_4
XU984 n684 n543 n541 B[17] SEN_MUXI2_S_2
XU985 n690 n543 n541 B[18] SEN_MUXI2_S_2
XU986 n1007 n1016 n1022 n941 SEN_AOI21_S_2
XU987 n965 n633 n360 SEN_ND2_G_3
XU988 n655 n635 n939 SEN_ND2_2
XU989 n1029 n937 n936 SEN_ND2_T_4
XU990 n943 n961 n962 SEN_EO2_1
XU991 n906 n986 n987 SEN_EO2_2
XU992 n981 n689 n688 n687 SEN_ND3_T_2
XU993 n603 n536 n602 SEN_ND2_T_1
XU994 n699 n985 n914 SEN_NR2_T_1P5
XU995 n924 n921 n922 SEN_EO2_2
XU996 n832 n539 A[13] n599 SEN_AOI21_T_3
XU997 n922 n539 A[11] n577 SEN_AOI21_T_3
XU998 n899 n898 n897 SEN_EO2_2
XU999 n936 n935 SEN_INV_2
XU1000 n935 n1039 n1038 SEN_NR2_2
XU1001 n878 n705 n704 n703 SEN_OAI21_S_3
XU1002 n722 n533 n721 SEN_ND2_T_1
XU1003 n651 n533 n650 SEN_ND2_T_1
XU1004 n597 n533 n596 SEN_ND2_G_3
XU1005 n830 n838 n839 SEN_EO2_2
XU1006 n933 n931 n932 SEN_EO2_5
XU1007 n932 n566 n565 n564 SEN_ND3_3
XU1008 n598 n536 n595 SEN_ND2_T_1P5
XU1009 n683 n682 n779 n681 SEN_ND3_1
XU1010 n626 n1020 SEN_INV_2
XU1011 n940 n626 n625 SEN_ND2_G_3
XU1012 Z[27] n866 n549 n865 n864 SEN_OAI211_3
XU1013 n599 n598 n779 n597 SEN_ND3_T_2
XU1014 n944 n614 n360 SEN_ND2_2
XU1015 n625 n1019 SEN_INV_2
XU1016 n531 INST[2] SEN_BUF_6
XU1017 n529 INST[0] SEN_BUF_6
XU1018 n953 n959 n952 SEN_EO2_2
XU1019 n952 n951 n527 n950 SEN_OA21B_2
XU1020 n595 n554 A[13] SEN_EO2_2
XU1021 n804 n810 n803 SEN_EO2_2
XU1022 n976 n971 n367 SEN_ND2_2
XU1023 n559 n529 n531 SEN_ND2_T_5
XU1024 n546 n360 SEN_INV_10
XU1025 n879 n878 SEN_INV_2
XU1026 n854 n659 SEN_INV_3
XU1027 n659 n605 n604 n603 SEN_ND3_T_3
XU1028 n1054 n639 n545 SEN_NR2_T_1P5
XU1029 n813 n812 n811 SEN_EO2_2
XU1030 n890 n539 A[23] n724 SEN_AOI21_T_1
XU1031 n536 n538 SEN_INV_S_8
XU1032 n912 n539 A[19] n667 SEN_AOI21_S_2
XU1033 n667 n666 n779 n665 SEN_ND3_1
XU1034 n663 n554 A[19] SEN_EO2_1
XU1035 n996 n991 n992 SEN_EO2_2
XU1036 n971 n977 n970 SEN_EO2_1
XU1037 n853 n606 n545 SEN_NR2_T_3
XU1038 n858 n853 n659 SEN_EO2_2
XU1039 n653 n652 n779 n651 SEN_ND3_T_2
XU1040 n649 n554 A[2] SEN_EO2_1
XU1041 n576 n536 n573 SEN_ND2_T_1
XU1042 n577 n576 n779 n575 SEN_ND3_T_2
XU1043 n573 n555 A[11] SEN_EO2_2
XU1044 n648 n647 n779 n646 SEN_ND3_2
XU1045 n852 n858 n851 SEN_EO2_1
XU1046 Z[9] n1036 n996 n995 n994 SEN_OAI211_1
XU1047 n838 n831 n832 SEN_EO2_2
XU1048 n1016 n1025 n1028 n939 SEN_OAI21_S_3
XU1049 n963 n962 n961 n960 SEN_AOI21_2
XU1050 n931 n558 n545 SEN_NR2_T_3
XU1051 n1027 n623 SEN_INV_3
XU1052 n855 n854 n853 n366 SEN_NR3_G_1
XU1053 n764 n859 n860 n823 SEN_ND3_T_0P8
XU1054 n1040 n1039 n1038 n1053 SEN_NR3_G_1
XU1055 n1021 n1020 n526 n1053 n1018 SEN_OAI31_G_1
XU1056 n1010 n791 n790 SEN_NR2_1
XU1057 n1057 n790 n1050 n530 SEN_NR3_G_1
XU1058 n692 n553 A[18] SEN_EO2_S_0P5
XU1059 n826 n539 A[25] n737 SEN_AOI21_S_1
XU1060 n780 n534 n553 n779 SEN_OAI21_S_0P5
XU1061 n783 n802 n799 n796 n784 SEN_OAI211_1
XU1062 n797 n549 n796 n795 SEN_OAI21_G_1
XU1063 n775 n536 n774 SEN_ND2_G_1
XU1064 n760 n535 n757 SEN_ND2_G_1
XU1065 n767 n532 n766 SEN_ND2_G_1
XU1066 n768 n535 n765 SEN_ND2_G_1
XU1067 n547 n360 SEN_INV_S_1
XU1068 n995 n990 n367 SEN_ND2_G_1
XU1069 n1014 n1008 n367 SEN_ND2_G_1
XU1070 Z[1] n1045 n1044 n1043 n1042 SEN_OAI211_1
XU1071 Z[2] n1036 n1035 n1034 n1033 SEN_OAI211_1
XU1072 n1034 n1030 n1058 SEN_ND2_G_1
XU1073 Z[8] n1006 n1044 n1005 SEN_OAI21_G_1
XU1074 n1003 n1002 n1001 n1000 SEN_OAI21_G_1
XU1075 n1002 n999 n1010 SEN_ND2_G_1
XU1076 n1004 n998 n549 SEN_NR2_1
XU1077 n925 n924 n548 SEN_ND2_G_1
XU1078 n755 n535 n752 SEN_ND2_G_1
XU1079 n736 n535 n733 SEN_ND2_G_1
XU1080 n743 n532 n742 SEN_ND2_G_1
XU1081 n744 n535 n741 SEN_ND2_G_1
XU1082 n984 n979 n367 SEN_ND2_G_1
XU1083 n948 n961 n548 SEN_ND2_G_1
XU1084 n949 n943 n367 SEN_ND2_G_1
XU1085 n968 n964 n367 SEN_ND2_G_1
XU1086 n730 n535 n729 SEN_ND2_G_1
XU1087 n910 n913 n908 SEN_ND2_G_1
XU1088 n715 n535 n714 SEN_ND2_G_1
XU1089 n709 n535 n708 SEN_ND2_G_1
XU1090 n704 n702 n907 SEN_NR2_1
XU1091 n705 n914 n913 n698 n908 SEN_OAI211_1
XU1092 n908 n697 n915 SEN_ND2_G_1
XU1093 n913 n696 n981 SEN_ND2_G_1
XU1094 n693 n535 n692 SEN_ND2_G_1
XU1095 n687 n535 n686 SEN_ND2_G_1
XU1096 n681 n533 n680 SEN_ND2_G_1
XU1097 n682 n535 n679 SEN_ND2_G_1
XU1098 n671 n533 n670 SEN_ND2_G_1
XU1099 n950 n912 n911 SEN_NR2_1
XU1100 n665 n533 n664 SEN_ND2_G_1
XU1101 n666 n536 n663 SEN_ND2_G_1
XU1102 n652 n536 n649 SEN_ND2_G_1
XU1103 n646 n533 n645 SEN_ND2_G_1
XU1104 n647 n536 n644 SEN_ND2_G_1
XU1105 n642 n639 n1047 n640 SEN_OAI21_G_1
XU1106 n605 n540 A[14] SEN_ND2_G_1
XU1107 n590 n536 n589 SEN_ND2_G_1
XU1108 n581 n536 n580 SEN_ND2_G_1
XU1109 n583 n540 A[12] SEN_ND2_G_1
XU1110 n575 n533 n574 SEN_ND2_G_1
XU1111 n569 n537 n568 SEN_ND2_G_1
XU1112 n564 n535 n563 SEN_ND2_G_1
XU1113 n723 n535 n720 SEN_ND2_G_1
XU1114 n793 n539 n553 n780 SEN_AOI21_S_1
XU1115 n776 n532 n772 n364 SEN_AOI21_S_1
XU1116 n822 n539 A[28] n761 SEN_AOI21_S_1
XU1117 n757 n553 A[28] SEN_EO2_S_0P5
XU1118 n815 n539 A[29] n769 SEN_AOI21_S_1
XU1119 n993 n991 n992 n1010 SEN_AN3B_1
XU1120 n1045 n1041 n1037 SEN_EN2_0P5
XU1121 n1023 n1022 n548 n1021 SEN_AOI21_S_1
XU1122 n1024 n1017 n1016 SEN_EO2_S_0P5
XU1123 n1017 n1022 SEN_INV_S_1
XU1124 n862 n539 A[27] n756 SEN_AOI21_S_1
XU1125 n752 n553 A[27] SEN_EO2_S_0P5
XU1126 n751 n543 n541 B[27] SEN_MUXI2_S_1
XU1127 n733 n554 A[25] SEN_EO2_S_0P5
XU1128 n738 n361 n541 B[25] SEN_MUXI2_S_1
XU1129 n872 n539 A[26] n745 SEN_AOI21_S_1
XU1130 n741 n553 A[26] SEN_EO2_S_0P5
XU1131 n740 n361 n541 B[26] SEN_MUXI2_S_1
XU1132 n982 n980 n981 n1010 SEN_AN3B_1
XU1133 n946 n945 n944 n1010 SEN_ND3_S_0P5
XU1134 n974 n972 n973 n1010 SEN_AN3B_1
XU1135 n961 n934 SEN_INV_S_1
XU1136 n941 n940 SEN_INV_S_1
XU1137 n731 n532 n728 n365 SEN_AOI21_S_1
XU1138 n714 n553 A[21] SEN_EO2_S_0P5
XU1139 n716 n532 n713 n365 SEN_AOI21_S_1
XU1140 n712 n543 n541 B[21] SEN_MUXI2_S_1
XU1141 n708 n553 A[22] SEN_EO2_S_0P5
XU1142 n710 n532 n707 n365 SEN_AOI21_S_1
XU1143 n706 n361 n541 B[22] SEN_MUXI2_S_1
XU1144 n887 n970 SEN_INV_S_1
XU1145 n694 n532 n691 n364 SEN_AOI21_S_1
XU1146 n686 n554 A[17] SEN_EO2_S_0P5
XU1147 n688 n532 n685 n364 SEN_AOI21_S_1
XU1148 n679 n554 A[16] SEN_EO2_S_0P5
XU1149 n678 n543 n541 B[16] SEN_MUXI2_S_1
XU1150 n675 n912 SEN_INV_S_1
XU1151 n669 n554 A[20] SEN_EO2_S_0P5
XU1152 n1048 n540 A[0] n535 n637 SEN_AOI22_1
XU1153 n637 n554 A[0] SEN_EO2_S_0P5
XU1154 n633 n542 n544 n632 SEN_MUXI2_S_1
XU1155 n630 n532 n627 n363 SEN_AOI21_S_1
XU1156 n621 n542 n544 n620 SEN_MUXI2_S_1
XU1157 n618 n532 n615 n365 SEN_AOI21_S_1
XU1158 n604 n532 n601 n365 SEN_AOI21_S_1
XU1159 n589 n555 A[8] SEN_EO2_S_0P5
XU1160 n582 n532 n579 n365 SEN_AOI21_S_1
XU1161 n537 n538 SEN_INV_S_1
XU1162 n570 n533 n567 n365 SEN_AOI21_S_1
XU1163 n563 n553 A[10] SEN_EO2_S_0P5
XU1164 n565 n532 n561 n364 SEN_AOI21_S_1
XU1165 n528 B[7] A[7] n1057 SEN_OA21_1
XU1166 FLAGS[3] SEN_TIE0_1
.ENDS
.GLOBAL VDD
.GLOBAL VSS
